/*
 * +==========================================================================+
 * |      ESP32-CAM Hellboy's WatchTower Surveillance Dashboard (Blue)        |
 * |          Hardware : AI Thinker ESP32-CAM  |  OV2640  |  HW-381 MB        |
 * |            Version  : 1.0.0                                              |
 * +==========================================================================+
 * |  REQUIRED LIBRARIES (Arduino IDE -> Manage Libraries):                   |
 * |    - "Universal Arduino Telegram Bot"  by Brian Lough                    |
 * |    - "ArduinoJson"                     by Benoit Blanchon  (v6.x)        |
 * |                                                                          |
 * |  BOARD SETTINGS:                                                         |
 * |    Board            : AI Thinker ESP32-CAM                               |
 * |    Partition Scheme : Huge APP (3MB No OTA / 1MB SPIFFS)                 |
 * |    CPU Frequency    : 240 MHz                                            |
 * |    Upload Speed     : 115200                                             |
 * +==========================================================================+
 */

// ============================================================
//  USER CONFIGURATION -- Fill in before flashing
// ============================================================
// WiFi + Telegram credentials loaded from Preferences (NVS) at boot.
// Configure via dashboard Settings panel. No hardcoded credentials.
#define AP_SSID     "ESP32HBWT"
#define AP_PASS     "watchtower"
#define AP_IP_STR   "192.168.4.1"

// Motion Detection - THESE ARE THE TUNED DEFAULTS
// mdThreshold: mean absolute difference of grayscale values (0-255)
//   lower  = more sensitive (fires easier)
//   higher = less sensitive (only fires on big movement)
//   Good range: 4.0 (very sensitive) to 20.0 (only large motion)
#define MD_THRESHOLD_DEFAULT    8.0f   // MAD trigger level
#define MOTION_SENSITIVITY_DEFAULT  50  // 1-100 slider position for above
#define MOTION_COOLDOWN_DEFAULT_S    8  // seconds between repeated alerts
#define MD_WARMUP_FRAMES           20  // frames to discard at startup / arm

#define NTP_SERVER          "pool.ntp.org"
// POSIX TZ string handles DST transitions automatically.
// Change this to match your timezone. Examples:
//   Central European : "CET-1CEST,M3.5.0,M10.5.0/3"
//   UK               : "GMT0BST,M3.5.0/1,M10.5.0"
//   US Eastern       : "EST5EDT,M3.2.0,M11.1.0"
//   US Pacific       : "PST8PDT,M3.2.0,M11.1.0"
#define POSIX_TZ            "CET-1CEST,M3.5.0,M10.5.0/3"

// -- Camera quality tuning -------------------------------------
// JPEG quality: lower number = higher quality / larger file
//   Stream: 12 keeps frames small for smooth WiFi delivery
//   Photo:  8 gives good detail without exhausting PSRAM
// Photo resolution: SVGA (800x600) is reliable on this hardware.
// UXGA (1600x1200) often produces blank frames due to PSRAM limits.
#define STREAM_JPEG_QUALITY   12
#define PHOTO_JPEG_QUALITY     6
#define PHOTO_FRAMESIZE        FRAMESIZE_XGA    // 1024x768 - good quality still
// ============================================================

#include "esp_camera.h"
#include "img_converters.h"
#include "Arduino.h"
#include "soc/soc.h"
#include "soc/rtc_cntl_reg.h"
#include "driver/rtc_io.h"
#include <WiFi.h>
#include <WiFiClientSecure.h>
#include <WebServer.h>
#include <SD_MMC.h>
#include <FS.h>
#include <Preferences.h>
#include <time.h>
#include <esp_http_server.h>
#include <UniversalTelegramBot.h>
#include <ArduinoJson.h>
#include <vector>
#include <algorithm>

// ============================================================
//  AI THINKER PIN MAP
// ============================================================
#define PWDN_GPIO_NUM   32
#define RESET_GPIO_NUM  -1
#define XCLK_GPIO_NUM    0
#define SIOD_GPIO_NUM   26
#define SIOC_GPIO_NUM   27
#define Y9_GPIO_NUM     35
#define Y8_GPIO_NUM     34
#define Y7_GPIO_NUM     39
#define Y6_GPIO_NUM     36
#define Y5_GPIO_NUM     21
#define Y4_GPIO_NUM     19
#define Y3_GPIO_NUM     18
#define Y2_GPIO_NUM      5
#define VSYNC_GPIO_NUM  25
#define HREF_GPIO_NUM   23
#define PCLK_GPIO_NUM   22
#define FLASH_LED_PIN    4
// LEDC channel for flash LED PWM - must not conflict with camera LEDC_CHANNEL_0
// Camera uses LEDC_CHANNEL_0 for XCLK. We use channel 1 for the flash LED.
#define FLASH_LEDC_CHANNEL  1
#define FLASH_LEDC_FREQ     5000   // 5 kHz - same as CameraWebServer
#define FLASH_LEDC_RES      8      // 8-bit = 0-255
static int ledDuty = 0;  // current LED PWM duty (0=off, 255=full)

// ============================================================
//  MOTION DETECTION BUFFERS
//  JPG_SCALE_8X: VGA 640x480  ?  80x60 grayscale = 4800 bytes
//  Using 8x scale (not 4x) makes the diff faster and less noisy
// ============================================================
#define MD_W       80
#define MD_H       60
#define MD_PIXELS  (MD_W * MD_H)     // 4800

// Each buffer holds one grayscale frame (1 byte per pixel)
static uint8_t* prevGray       = nullptr;
static uint8_t* currGray       = nullptr;
static bool     prevFrameReady = false;

// Warm-up counter - discard first N frames after arming
static int  mdWarmupCount  = 0;
static bool mdWarmedUp     = false;

// Consecutive-hit counter - require 2 hits before firing
static int  mdConsecutive  = 0;
#define MD_CONSEC_REQUIRED  2

// Actual float threshold derived from slider
static float mdThreshold = MD_THRESHOLD_DEFAULT;

// ============================================================
//  AVI WRITER
// ============================================================
#define AVI_MAX_FRAMES 3000
static File     aviFile;
// Note: idx1 index chunk is not written (dwFlags=0x00 in avih).
// The offset/size arrays were previously allocated but never used.
// 24 KB of PSRAM freed back to camera buffers and WiFi stack.
static int      aviFrameCount   = 0;
static unsigned long aviStartMs = 0;
static bool     aviRecording    = false;
static char     aviFilePath[96] = "";
static uint32_t aviMoviOffset   = 0;
// Actual pixel dimensions extracted from first frame's JPEG header
static int      aviWidth        = 640;
static int      aviHeight       = 480;

// ============================================================
//  GLOBAL STATE
// ============================================================
volatile bool  streamActive      = false;
bool  motionArmed       = false;   // ? OFF by default (v2.2 fix)
bool  telegramEnabled   = false;  // enabled once credentials loaded from NVS
bool  emailEnabled      = false;  // reserved for future email alert feature
// Runtime credentials - loaded from Preferences in setup()
static String cfgWifiSSID  = "";
static String cfgWifiPass  = "";
static String cfgBotToken  = "";
static String cfgChatID    = "";
static bool   apMode       = false;  // true when running as AP (no router)

int   motionSensitivity = MOTION_SENSITIVITY_DEFAULT;
int   motionCooldownS   = MOTION_COOLDOWN_DEFAULT_S;

unsigned long lastMotionMs   = 0;
unsigned long lastTelegramMs = 0;
unsigned long bootMs         = 0;   // set in setup() for uptime tracking

// ── Timelapse ──────────────────────────────────────────────────
bool          timelapseActive    = false;
int           timelapseIntervalS = 30;   // seconds between captures
unsigned long lastTimelapseMs    = 0;

int photoCount = 0;
int videoCount = 0;

// OPT: Events list cache - avoids full SD directory scan on every /api/events call.
// Set dirty whenever photoCount or videoCount changes (capture, delete, deleteAll).
static bool   eventsCacheDirty = true;   // force scan on first request
static int    eventsCachePhotoSnap = -1; // photoCount snapshot at last scan
static int    eventsCacheVideoSnap = -1; // videoCount snapshot at last scan

// Stream quality settings (changeable from dashboard)
// framesize_t values: FRAMESIZE_QVGA=5, VGA=8, SVGA=9, XGA=10, SXGA=12, UXGA=13
int  streamFrameSize = FRAMESIZE_VGA;   // default VGA
int  streamFps       = 10;              // default 10 fps

// Events pagination - limit displayed to avoid memory exhaustion
#define EVENTS_PAGE_SIZE  20

httpd_handle_t      streamHttpd = NULL;
Preferences         preferences;
WebServer           webServer(80);
WiFiClientSecure    securedClient;
UniversalTelegramBot* bot = nullptr;

// -- Telegram background task -----------------------------------
// All Telegram I/O runs on Core 0. loop() on Core 1 never blocks.
typedef enum { TG_TEXT, TG_PHOTO, TG_VIDEO } TgJobType;
// OPT: union payload - path/caption and text are mutually exclusive by job type.
// Saves ~640 bytes per queue slot = ~3.5KB total queue SRAM vs the old flat struct.
struct TgJob {
  TgJobType type;
  union {
    struct {
      char path[128];    // SD path (PHOTO/VIDEO jobs)
      char caption[384]; // caption (PHOTO/VIDEO jobs) - was 512, trimmed to fit union
    };
    char text[512];      // body (TG_TEXT jobs)
  };
};
static QueueHandle_t     tgQueue    = nullptr;  // created in setup()
static SemaphoreHandle_t sdMutex    = nullptr;  // guards all SD_MMC calls
static SemaphoreHandle_t tgBusySem  = nullptr;  // binary sem: taken while TLS send in progress
// tgBusySem serialises all TLS operations within telegramTask.
// Only one mbedTLS session runs at a time - two simultaneous sessions
// exhaust heap and cause silent failures.

// -- Pending-job state machine (Item 5) -------------------------
// HTTP handlers are called from webServer.handleClient() on the main
// task. Heavy work (photo/record) sets a pending flag and returns
// immediately so handleClient() never blocks for 2-30 seconds.
// loop() checks and executes pending jobs each iteration.
typedef enum { JOB_NONE, JOB_PHOTO, JOB_RECORD } PendingJobType;
struct PendingJob {
  PendingJobType type     = JOB_NONE;
  bool           flash    = false;
  int            recSecs  = 10;
};
static volatile PendingJob pendingJob;


// ============================================================
//  FORWARD DECLARATIONS
// ============================================================
void   tgEnqueue(const String& msg);
void   tgEnqueuePhoto(const String& path, const String& cap);
void   tgEnqueueVideo(const String& path, const String& cap);
void   tgSend(const String& msg);
void   executePendingJob();
void   sendPhotoToTelegram(const String& filePath, const String& caption);
void   sendVideoToTelegram(const String& filePath, const String& caption);
bool   captureAndSavePhoto(bool sendTg, String triggerLabel, bool useFlash);
bool   startAVIRecording(int durationSec);
bool   addAVIFrame(camera_fb_t* fb);
String finishAVIRecording();
bool   checkMotion(camera_fb_t* fb);
int    countPhotos();
int    countVideos();
String getTimestamp();
String getUptime();
void   runTelegramRecord(int secs);
void   armMotion();
void   disarmMotion();
void   applyStreamResolution();
void   deleteAllSD();
// Convert slider 1-100 -> float threshold (inverse: high slider = low threshold)
inline float sliderToThreshold(int s) {
  // slider 1   -> ~13.88  (least sensitive, barely triggers)
  // slider 50  ->   8.0   (default, matches MD_THRESHOLD_DEFAULT)
  // slider 100 ->   2.0   (most sensitive)
  return 14.0f - (s * 12.0f / 100.0f);
}

// ============================================================
//  EMBEDDED WEB DASHBOARD - gzip-compressed (73% smaller)
// ============================================================
// Dashboard HTML gzip-compressed: 11285 bytes (was 31292 bytes plain)
static const uint16_t DASHBOARD_HTML_GZ_LEN = 12752;
static const uint8_t  DASHBOARD_HTML_GZ[] PROGMEM = {
  0x1f,0x8b,0x08,0x00,0x7e,0x3a,0xbc,0x69,0x02,0xff,0xcd,0x7d,0xeb,0x7a,0xda,0xc8,
  0xb2,0xe8,0x7f,0x3f,0x85,0x86,0xf9,0x56,0x04,0xcb,0x80,0xc5,0xc5,0x18,0x43,0x70,
  0x36,0xc6,0xd8,0x66,0x8d,0x0d,0x1e,0xc0,0xf1,0x24,0x99,0xf9,0xf2,0x09,0x10,0xa0,
  0x44,0x20,0x96,0x24,0xdf,0x42,0xbc,0xbf,0xf5,0x08,0xe7,0xc7,0x3e,0x2f,0x70,0x1e,
  0x6d,0x3d,0xc9,0xa9,0xea,0x8b,0xd4,0xba,0x20,0x64,0x3b,0x6b,0xf6,0xcc,0x25,0x01,
  0xa9,0xbb,0xba,0xba,0xba,0xba,0x6e,0x5d,0x5d,0xbc,0xfd,0xe9,0xa4,0xd7,0x1a,0x7e,
  0xb8,0x6a,0x4b,0x73,0x67,0x61,0x1c,0xed,0xbc,0xc5,0xbf,0x24,0x43,0x5d,0xce,0x1a,
  0x29,0x6d,0x99,0xc2,0x07,0x9a,0x3a,0x81,0xbf,0x16,0x9a,0xa3,0x4a,0xe3,0xb9,0x6a,
  0xd9,0x9a,0xd3,0x48,0x5d,0x0f,0x4f,0x73,0xd5,0x14,0x7f,0xbc,0x54,0x17,0x5a,0x23,
  0x75,0xa7,0x6b,0xf7,0x2b,0xd3,0x72,0x52,0xd2,0xd8,0x5c,0x3a,0xda,0x12,0x9a,0xdd,
  0xeb,0x13,0x67,0xde,0x98,0x68,0x77,0xfa,0x58,0xcb,0x91,0x2f,0x59,0x7d,0xa9,0x3b,
  0xba,0x6a,0xe4,0xec,0xb1,0x6a,0x68,0x8d,0x02,0xc2,0x30,0xf4,0xe5,0x57,0xc9,0xd2,
  0x8c,0x46,0x4a,0x87,0x9e,0x29,0xc9,0x79,0x5c,0x01,0x38,0x7d,0xa1,0xce,0xb4,0x3d,
  0xfb,0x6e,0xb6,0xfb,0xb0,0x30,0x52,0xd2,0xdc,0xd2,0xa6,0x8d,0xd4,0x44,0x75,0xd4,
  0x9a,0xef,0x4d,0x7d,0xa4,0xda,0x5a,0xa5,0x9c,0xbd,0x3a,0xef,0x16,0x3f,0x3e,0x1e,
  0x97,0x47,0x37,0x0f,0xb7,0xe3,0x6f,0x8a,0xae,0x9e,0xf7,0x95,0xf1,0x89,0x79,0x77,
  0x51,0x9a,0x94,0x26,0x8f,0xfb,0xa5,0xcb,0xc7,0xfd,0xbb,0xf1,0x62,0x7c,0x77,0xf9,
  0xa5,0x79,0x7f,0xd9,0x3a,0xfc,0x36,0x59,0x8c,0xf5,0xce,0xf9,0xc7,0xd5,0xc7,0xdf,
  0x26,0xad,0x51,0x69,0x76,0xd8,0xf9,0xd2,0x9c,0x5d,0xb6,0x9a,0xdf,0x2e,0x75,0xfc,
  0xbf,0xb3,0x7b,0x75,0xfe,0x0f,0xe3,0x43,0xe9,0xd7,0xd9,0xa4,0x68,0x7c,0x9d,0x9c,
  0xe1,0xfb,0xcb,0xc7,0x8e,0x7e,0x6c,0x7e,0xbc,0x31,0x96,0xea,0xf9,0xaf,0xfc,0xfb,
  0xa3,0x76,0xa2,0xe8,0x5d,0xbd,0x33,0xfb,0xb8,0x30,0xec,0x11,0x7c,0xee,0x7c,0x6b,
  0x16,0x2e,0x4f,0xc6,0xf7,0xbd,0x41,0xe7,0xee,0xea,0xcb,0xc3,0xe3,0xc7,0x9b,0xae,
  0xd2,0x39,0xc7,0xfe,0xbf,0xc2,0x78,0x5f,0xe1,0xef,0xf6,0x3d,0xf4,0x2b,0xa9,0x37,
  0x7d,0x45,0x85,0xf6,0x97,0xf8,0xfc,0x6c,0x6e,0xa8,0x37,0x13,0x73,0x82,0xdf,0x87,
  0x88,0xd7,0x3f,0xca,0x57,0x83,0xce,0x37,0x68,0xb7,0x50,0x6f,0x1e,0x6c,0xf8,0xfc,
  0xe5,0xf2,0xe4,0xf8,0x6b,0xf7,0xec,0xe3,0xa2,0xa3,0x57,0x77,0xaf,0xce,0xba,0xab,
  0xf1,0xa2,0x6b,0x7f,0x1c,0x1c,0x7f,0xd1,0x48,0x9f,0x0f,0x00,0xa3,0xbb,0x0f,0xed,
  0x1e,0x7a,0xad,0xce,0x6c,0xfc,0x05,0x70,0x1a,0x94,0x0b,0xfe,0xfe,0xd7,0xf7,0xdd,
  0x6f,0xcd,0xfd,0xa4,0xfd,0x2f,0x1f,0x83,0xfd,0x8f,0x17,0x1f,0xbf,0xfc,0xfa,0x40,
  0xfa,0x33,0xda,0xd0,0xbe,0x6d,0x36,0x2f,0xc4,0x7b,0xb2,0xfa,0x78,0xde,0x37,0xa1,
  0x7d,0xd1,0x4f,0xab,0x5f,0xf9,0x9c,0x1e,0x2e,0xbe,0x5c,0xc3,0x58,0x1f,0x57,0xa3,
  0xb3,0xfb,0xc3,0x8e,0x7e,0x79,0x7f,0x79,0xf6,0xab,0xf2,0x71,0xf1,0x41,0xbf,0xf8,
  0x56,0xae,0x7e,0x28,0x1a,0x8f,0x1f,0x8a,0x0f,0x06,0xe0,0x82,0x6d,0x1f,0xbb,0x83,
  0xce,0xec,0x43,0x89,0xd0,0x0c,0x69,0xf1,0x18,0xee,0xdf,0x5d,0x5c,0x9e,0x7d,0x28,
  0x7e,0x5c,0x5c,0x92,0xfe,0x17,0x25,0xe0,0x81,0x6f,0xe5,0x06,0x32,0x95,0xa3,0x3b,
  0x86,0x76,0x74,0x7e,0x7c,0x33,0x94,0xf6,0xf6,0xa4,0xc1,0x75,0xff,0x7d,0xbb,0x73,
  0x71,0xd1,0xec,0xb6,0xda,0x52,0xa7,0x3b,0x6c,0x5f,0x5c,0x74,0xce,0xda,0xf8,0xa5,
  0xdb,0x1e,0xde,0xf4,0xfa,0xbf,0xbc,0xdd,0xa3,0x1d,0x44,0x6e,0x5c,0x59,0x1a,0xf0,
  0xe3,0x52,0x1b,0x3b,0x9c,0xfd,0xe6,0x8e,0xb3,0xb2,0x6b,0x7b,0x7b,0x53,0x60,0x70,
  0x3b,0x3f,0x33,0xcd,0x99,0xa1,0xa9,0x2b,0xdd,0xce,0x8f,0xcd,0x45,0xea,0x79,0x7d,
  0x6d,0x47,0x75,0xf4,0x31,0xe9,0x28,0x8d,0x2d,0xd3,0xb6,0x4d,0x4b,0x9f,0xe9,0x4b,
  0x0e,0x64,0xfb,0x78,0x7b,0x63,0xdb,0x2e,0xbe,0x9b,0xaa,0x0b,0xdd,0x78,0x6c,0x0c,
  0x60,0x63,0x6a,0xbb,0x43,0x6d,0x3c,0xdf,0xbd,0x34,0x97,0xe6,0x1b,0xf6,0xb8,0xaf,
  0x7e,0x99,0xcc,0xd5,0xa5,0x5e,0xbb,0x9f,0xcd,0x9d,0xff,0x2a,0x2b,0x4a,0x7d,0x1f,
  0xfe,0xaf,0xc0,0xff,0x07,0x8a,0xf2,0x66,0xa2,0xdb,0x2b,0x43,0x7d,0x6c,0xd8,0xf7,
  0xea,0x2a,0x45,0xd1,0xb6,0x9d,0x47,0x43,0xb3,0xe7,0x9a,0xe6,0xe0,0x74,0xc8,0xb7,
  0xa3,0x9d,0x9a,0x65,0x9a,0xce,0x7a,0x47,0x92,0x72,0xb9,0xd1,0xac,0x26,0xd1,0x7f,
  0x7e,0x56,0xf6,0x95,0x03,0x45,0xad,0x93,0xc7,0x2b,0x75,0xa9,0x19,0x35,0xfa,0xf8,
  0x50,0x19,0x17,0x8a,0xf4,0xf1,0x58,0xb5,0x26,0x35,0xd6,0x7a,0x5c,0x28,0x14,0xaa,
  0xde,0xe3,0x22,0x6b,0x3d,0x2d,0xec,0x17,0x15,0xfa,0x78,0x64,0x5a,0x13,0xcd,0xc2,
  0xe7,0x3f,0x17,0xd4,0xe2,0x7e,0x69,0x5f,0x7c,0x8c,0xed,0x7f,0x2e,0x96,0x4b,0x4a,
  0x99,0xb5,0x1e,0x3f,0xaa,0x4b,0x0e,0x5b,0x99,0x94,0xa7,0x53,0xfa,0x78,0x66,0x69,
  0xda,0x92,0xc1,0x56,0xa6,0xd3,0x72,0x81,0x3e,0x56,0x17,0x23,0x0a,0x5a,0xfa,0x79,
  0x3a,0x3d,0x44,0x22,0x90,0xc7,0x96,0xc6,0xf0,0xc3,0xc7,0x30,0xa8,0xc6,0xa6,0x73,
  0x6b,0xad,0x0c,0x8d,0x60,0x72,0x38,0xda,0x57,0x39,0x6c,0xe7,0xc1,0xe1,0xad,0x47,
  0xd5,0x89,0xa2,0x29,0xee,0xe3,0x22,0xc3,0xa4,0xac,0x56,0xd4,0xaa,0xf7,0xb8,0xc4,
  0x1e,0x17,0x34,0x0f,0xef,0x05,0x2c,0x0f,0x7d,0x2c,0x93,0x45,0x93,0x70,0xd1,0x24,
  0x5c,0x34,0x39,0x8b,0xef,0xec,0x95,0x3a,0x66,0x68,0xd8,0xea,0xd2,0x66,0x4d,0xf9,
  0x42,0xca,0x59,0x79,0xa0,0xcd,0x4c,0x4d,0xba,0xee,0xc8,0x59,0x7c,0x9f,0xb3,0x35,
  0x4b,0xe7,0x73,0x37,0xcc,0xfb,0xdc,0x18,0x7b,0x28,0xf0,0x6f,0xa1,0xb8,0x7a,0xe0,
  0xb4,0xa9,0x28,0x42,0x8b,0x59,0xb0,0x05,0x92,0xc9,0xd7,0xc2,0xf2,0xb7,0xa0,0xa4,
  0xf1,0xb5,0x50,0x83,0x2d,0x90,0xa6,0xd8,0xe2,0x69,0xe7,0xef,0xeb,0x91,0xf9,0x90,
  0xb3,0xf5,0x6f,0xfa,0x72,0x56,0xa3,0x8b,0x07,0x6b,0xf8,0x50,0x5f,0xa8,0x16,0xf0,
  0x77,0x4d,0xa9,0xaf,0xd4,0xc9,0x04,0xdf,0x29,0x75,0x1b,0x18,0xdf,0x30,0x46,0xaa,
  0x45,0x75,0x43,0xcd,0x99,0xeb,0x4b,0xe1,0xe1,0xd8,0x34,0x4c,0xab,0xc6,0x98,0x81,
  0x33,0xdc,0xd3,0xce,0xc8,0x9c,0x3c,0xae,0x71,0x47,0xe4,0x28,0x97,0xd7,0xee,0x54,
  0x2b,0x4d,0xa9,0x95,0x01,0x6d,0x30,0xfe,0x3a,0xb3,0xcc,0xdb,0xe5,0x84,0x3d,0x1e,
  0xcd,0x32,0x75,0x0a,0x88,0x7e,0x87,0x65,0xc9,0xd4,0x17,0xfa,0x32,0x37,0xd7,0x74,
  0xd8,0x14,0xb5,0x82,0xa2,0xdc,0xcd,0xeb,0x04,0x1c,0xe0,0xac,0xd5,0x0a,0xfb,0xab,
  0x87,0xa7,0x9d,0x9d,0xbd,0xbf,0x4b,0xff,0xfe,0x9f,0x7f,0xc1,0x7f,0xd2,0xa0,0xd5,
  0xec,0x5e,0x74,0xba,0x6d,0xc9,0xbc,0xd3,0x2c,0xd8,0x2e,0xfc,0xf9,0xdf,0xf7,0x08,
  0x26,0xb5,0xda,0x48,0x9b,0x9a,0x96,0xb6,0x66,0x4a,0xaf,0x26,0xcb,0xf5,0x95,0x69,
  0x83,0x92,0x33,0x97,0xb5,0xa9,0xfe,0xa0,0x4d,0xea,0xfa,0x12,0x74,0x26,0x4e,0xdc,
  0xd4,0xa1,0x89,0x95,0xd3,0xee,0xa0,0x9d,0x5d,0x5b,0x9a,0x4b,0xad,0xfe,0x2d,0xa7,
  0x2f,0x27,0xda,0x43,0xed,0x10,0xfe,0x41,0xfa,0x0a,0xf8,0x5b,0xda,0x4a,0x03,0x19,
  0xb1,0x9c,0xe5,0x40,0x22,0x68,0x40,0x8f,0x99,0xa5,0x4e,0x74,0xe8,0x9a,0x56,0x26,
  0xda,0x2c,0xeb,0x58,0x30,0xe1,0x15,0x70,0xd0,0xd2,0x11,0x3f,0x4b,0xb0,0x20,0x59,
  0x6b,0x36,0x52,0xd3,0x4a,0xb6,0x58,0x28,0x66,0x8b,0xfb,0xfb,0xd9,0xbc,0x52,0x28,
  0x66,0x36,0xbf,0x28,0xaf,0x1e,0x32,0xbe,0x29,0x9f,0xb7,0x9b,0x27,0xed,0xbe,0x30,
  0x51,0xb4,0x01,0x34,0x0b,0x45,0x00,0x93,0x19,0xb5,0xa9,0xa1,0x3d,0xd4,0x55,0x43,
  0x9f,0x2d,0x73,0xba,0xa3,0x2d,0xec,0xda,0x58,0xc3,0xb9,0xd5,0xbf,0xdc,0xda,0x8e,
  0x3e,0x7d,0xcc,0x71,0x6a,0x10,0x76,0xce,0x8d,0x34,0xe7,0x1e,0xf6,0x65,0x60,0x82,
  0x74,0x41,0x88,0xec,0x80,0x85,0xe3,0x9c,0xe2,0x38,0xe6,0xa2,0x56,0x00,0xae,0xb2,
  0x4d,0x43,0x9f,0x48,0x6c,0x15,0xc9,0xdb,0x0c,0x02,0x70,0xd9,0x47,0x2a,0x2a,0xab,
  0x87,0x3a,0x5b,0xc6,0x7d,0x98,0x9d,0x47,0x77,0xc0,0x61,0xfc,0xf5,0xb1,0xee,0x98,
  0x2b,0x20,0x3b,0x27,0x31,0xac,0x74,0x1d,0xd1,0xce,0xdd,0x5b,0xea,0xaa,0x86,0x7f,
  0xd4,0x67,0xf0,0xa1,0x02,0x1d,0x11,0x2f,0x64,0xda,0xb9,0x3a,0x31,0xef,0x01,0x32,
  0x0e,0x8f,0xd0,0x71,0x77,0x20,0xcb,0xe5,0xe7,0x13,0x2b,0x67,0x68,0x53,0x67,0xbd,
  0x6d,0xfe,0x08,0xb1,0x50,0x46,0x16,0xca,0x1b,0xe6,0xcc,0xcc,0xa1,0x45,0xb3,0xa6,
  0xdc,0x5d,0x12,0xd0,0x25,0x9f,0x09,0x32,0xf6,0xdc,0x02,0x79,0x5f,0x53,0x78,0x07,
  0x47,0x7b,0x08,0x8c,0x42,0x9a,0x4d,0x74,0x50,0x28,0x64,0x6e,0xc0,0xcc,0xb7,0x8b,
  0x65,0x1d,0x79,0xc2,0xe5,0x61,0xb1,0xb3,0x94,0x37,0x0a,0x1b,0xb7,0x07,0x79,0x7e,
  0x4f,0x7b,0x1d,0x20,0x3d,0x5c,0xbe,0xcf,0x1f,0x5a,0xda,0xa2,0x6e,0x68,0x0e,0x72,
  0x28,0xae,0x1a,0xd2,0x38,0x5f,0x28,0xc2,0x43,0x71,0xfb,0xa0,0xd8,0xcd,0xd4,0x71,
  0x9c,0x1c,0x61,0x3a,0x60,0xfd,0x45,0xed,0x76,0xb5,0xd2,0xac,0x31,0xd8,0x61,0x01,
  0x3c,0x8a,0x11,0x78,0xa0,0x8c,0xcb,0x88,0xe3,0xee,0x57,0xad,0xc0,0x18,0x28,0x50,
  0x33,0x21,0x54,0x94,0x8a,0xb6,0x60,0x2b,0x81,0xba,0xf3,0xd6,0x4e,0xb4,0x16,0x15,
  0xb2,0x14,0xf7,0xfa,0x54,0xcf,0x4d,0x40,0x89,0xd1,0x95,0xa8,0x7a,0x0b,0x81,0x1f,
  0x19,0xeb,0xe1,0xee,0xba,0xb5,0x6b,0xfb,0xca,0xdf,0xc2,0x52,0x84,0xa8,0x15,0x64,
  0x52,0x97,0x49,0xd8,0x73,0x22,0x50,0x33,0xfe,0xa5,0xac,0x83,0xa0,0x5e,0xa8,0x64,
  0xb1,0x56,0xb7,0x86,0xad,0xe5,0x66,0x52,0xd1,0x96,0x34,0xa0,0x0f,0x70,0x62,0xce,
  0xbc,0x75,0x24,0x7d,0x39,0x45,0x3b,0x58,0x13,0x50,0xcb,0x9b,0xd3,0xe9,0x3a,0x34,
  0x2e,0x28,0xa8,0x4d,0xa3,0xc2,0x6e,0x08,0x8e,0x63,0x49,0x85,0x4d,0xe3,0xfc,0xd7,
  0x57,0xed,0x71,0x6a,0x81,0x9d,0x6e,0x4b,0x0c,0xa7,0xb5,0xf2,0xb7,0x2c,0x6c,0x89,
  0xbf,0xad,0x7d,0x9c,0xaf,0xa0,0x34,0x90,0xc4,0x49,0x3f,0xed,0x87,0xdb,0x14,0x82,
  0x8d,0xb2,0x91,0x3d,0x23,0x86,0xb5,0xb6,0x0f,0x8b,0x73,0xde,0x32,0x28,0x36,0xc9,
  0x46,0xf4,0x62,0xfc,0xe1,0xa8,0xb3,0x24,0x9c,0x57,0x89,0x66,0x3c,0x66,0x87,0x44,
  0x8b,0x20,0x78,0xcf,0x05,0x10,0x6a,0xbe,0x83,0x10,0xfb,0xa0,0x1c,0x0a,0xb1,0xee,
  0x3e,0x0c,0xc4,0xb9,0x15,0xc5,0x3e,0x10,0x66,0xa1,0x4d,0x74,0x35,0x8d,0x8a,0x88,
  0xf2,0x24,0x18,0x65,0x20,0x86,0xd7,0x2e,0xfe,0xbc,0xf9,0xc8,0x30,0xc7,0x5f,0x61,
  0x62,0x4b,0xf5,0xce,0xcf,0xf0,0xc8,0xdd,0xa0,0xab,0x22,0x18,0x1f,0xa8,0xe0,0xa8,
  0x23,0x91,0x99,0x04,0xfd,0x10,0x3f,0xbd,0x4c,0x04,0x3d,0x04,0x99,0x0b,0xe3,0x91,
  0x65,0x88,0x98,0xf3,0xf8,0xd6,0x02,0x13,0xb6,0xc6,0x74,0x5c,0x3d,0x56,0x00,0x51,
  0xf2,0x1f,0xec,0x23,0xfd,0x01,0xba,0x28,0x94,0xd0,0x36,0x0d,0x91,0xaf,0x0a,0xed,
  0x36,0x89,0x9c,0x3a,0x79,0x46,0xc5,0x7e,0xbe,0xb0,0x6f,0xd3,0xc9,0xe7,0x55,0x10,
  0x96,0x77,0x5a,0x16,0x3f,0xd7,0xe6,0xa8,0xb9,0x45,0x72,0x84,0xb4,0x60,0x35,0x13,
  0x21,0xe4,0xd8,0x1c,0xa3,0x5e,0x44,0xed,0xc7,0xb1,0x5f,0x87,0x5e,0x34,0x3f,0xf4,
  0xae,0x87,0x82,0x0e,0xcd,0xa3,0x4a,0x54,0x41,0x6a,0x5b,0xee,0x3a,0xce,0x2c,0x7d,
  0x52,0xc7,0x3f,0x40,0x60,0x2e,0xe0,0x89,0xa3,0xe5,0xa8,0x74,0xb7,0x6b,0xea,0xad,
  0x63,0x4a,0xa5,0x02,0xaa,0x09,0xa2,0x52,0x88,0x7a,0x63,0xab,0x40,0xbe,0x00,0xdd,
  0x98,0x45,0x85,0x4d,0x7d,0x5c,0x00,0xe2,0xd1,0x72,0x42,0x9a,0x98,0xf3,0xc6,0xcf,
  0xb6,0x63,0x69,0xea,0xa2,0x05,0x46,0x38,0x13,0x87,0x53,0xdd,0xe1,0xad,0xea,0x02,
  0x43,0x96,0x15,0x94,0x9d,0x9c,0x51,0xd5,0x07,0xf6,0xbc,0x5a,0x21,0x8c,0x0a,0xe3,
  0x0b,0x33,0x8a,0x9e,0x44,0x61,0x1a,0x61,0x10,0xc0,0xe8,0xce,0x78,0xfe,0x04,0xfd,
  0xc3,0x98,0xa0,0x60,0x10,0x50,0x50,0xb0,0x15,0xb3,0x3d,0x98,0xbc,0x26,0x93,0xe5,
  0x84,0xa8,0x32,0x76,0x7c,0xda,0xf1,0x91,0xbe,0xd5,0xec,0x9f,0x0c,0x7c,0x94,0xc7,
  0x11,0xa2,0x6c,0x0f,0x7c,0x91,0xd9,0xb6,0x23,0xfc,0xbc,0x5e,0xa2,0xb4,0x77,0xd7,
  0x02,0x77,0x03,0x5d,0x08,0x6e,0xbb,0x28,0x9e,0x1d,0x02,0x3e,0x95,0x8a,0x7c,0x58,
  0x47,0x0e,0x9c,0x02,0x97,0xd4,0xe6,0xfa,0x64,0xa2,0x2d,0x9f,0x28,0x4e,0xb1,0xb6,
  0xa3,0x3a,0x02,0x64,0x6e,0x1d,0x8d,0x59,0x31,0x68,0x7d,0xc0,0x5f,0x16,0xa1,0x82,
  0xc2,0xd5,0x57,0x81,0x19,0x2f,0xde,0xc4,0x82,0xb6,0xe2,0x61,0xc8,0x58,0x14,0x58,
  0x59,0x7c,0x9e,0xa9,0x9b,0xb8,0xe1,0x9c,0xc7,0x5a,0xbe,0xcc,0xf0,0xcb,0x01,0xeb,
  0xad,0xfd,0x93,0x43,0xde,0xe3,0x6f,0x89,0xc7,0xbc,0xe6,0x1b,0x38,0x7e,0xb3,0x57,
  0x8a,0xb8,0xd9,0x83,0xe6,0x47,0xa4,0xb0,0x09,0xd9,0x20,0xe5,0xb8,0xed,0x1f,0x46,
  0xaf,0x9e,0xc0,0x4c,0xc5,0x3d,0x55,0x0d,0xcc,0x24,0x6a,0x35,0x98,0xe5,0xe6,0xd9,
  0x0b,0x64,0x47,0x86,0xf9,0x48,0x14,0x18,0x8c,0x51,0x0a,0x11,0x16,0x9e,0x37,0x58,
  0x9e,0x3a,0xaa,0x7c,0xc8,0x0d,0x06,0x87,0xbf,0x0b,0x75,0x62,0x37,0x76,0x21,0xaf,
  0x03,0x5d,0xd0,0xc1,0xdd,0xd8,0x81,0xa8,0x4c,0xdf,0xc6,0xe9,0xf5,0xbb,0x60,0xf7,
  0x1f,0xf7,0x9b,0xad,0x5f,0xda,0xc3,0xd0,0x16,0xaa,0xd5,0xd4,0x29,0x10,0x2f,0x9e,
  0x5b,0xd9,0x42,0xe0,0xb6,0xa0,0xbc,0x8a,0x9f,0xf8,0xee,0x0e,0xd0,0x91,0x98,0xdd,
  0x94,0x66,0x9c,0x9b,0xa3,0x55,0x6e,0x12,0xe7,0xa0,0x18,0x5c,0x00,0xb4,0x0f,0x50,
  0x47,0x2b,0x7e,0x77,0x6e,0xd8,0x6f,0x37,0x2f,0xc5,0xa9,0x51,0x29,0x44,0xbc,0x02,
  0xbf,0xd6,0x15,0xd7,0x19,0x1d,0x81,0x28,0x4d,0x2f,0x58,0xe1,0x11,0xfb,0xfe,0xc9,
  0x07,0x5d,0xd2,0x17,0x41,0xbd,0xee,0xbe,0x47,0xeb,0x0f,0xc8,0x21,0x88,0xde,0xba,
  0x27,0x72,0x89,0x58,0x64,0xa3,0x94,0xab,0xf8,0xce,0xc7,0xdf,0xd0,0x2f,0x81,0x27,
  0xc6,0x1e,0x07,0xe7,0x84,0xdb,0x37,0xd2,0xc1,0x20,0x6a,0x47,0x89,0xd4,0xf5,0xee,
  0xba,0x91,0xa5,0x98,0xa8,0xf6,0x5c,0x0b,0xae,0x85,0x6f,0x66,0xd4,0x0b,0xf2,0xa4,
  0x01,0x91,0x05,0xae,0xb4,0x29,0xf9,0xdb,0x82,0x1c,0x48,0x62,0xbc,0x1d,0x14,0x13,
  0xba,0x0d,0xfb,0xc4,0x6d,0xe0,0x03,0x50,0x1f,0x7e,0x1d,0x2d,0x65,0xab,0xc4,0x76,
  0x9b,0x52,0xaf,0x20,0x64,0x6c,0x55,0x22,0x8d,0xad,0x28,0xaf,0xde,0x1b,0xcf,0x00,
  0x26,0xc8,0x8d,0xd4,0xc9,0x4c,0x13,0x9d,0x67,0xe2,0xf9,0x47,0xdb,0xfa,0x2c,0xe6,
  0x31,0x9d,0x4e,0xeb,0x49,0x2d,0x58,0x41,0x1b,0x45,0x9b,0xa4,0x85,0x08,0x93,0xb4,
  0x10,0x90,0xc6,0x65,0xca,0x0a,0x9e,0x47,0x31,0xc2,0x30,0x24,0xc1,0x5f,0x2a,0xe4,
  0x8b,0x09,0xdc,0x0a,0xaf,0x83,0x6b,0xe2,0xf3,0x25,0x2e,0x10,0x73,0xde,0x5d,0xf0,
  0x7d,0xb4,0xd3,0x81,0xdb,0x18,0x61,0x7e,0x0c,0x55,0xb8,0x1a,0x12,0x08,0x23,0x52,
  0xa5,0x9a,0x98,0x2a,0x4c,0xa1,0x20,0x3f,0xb0,0xd0,0x40,0xd8,0x4a,0x8a,0x26,0xd3,
  0x46,0x1f,0x8f,0x31,0x83,0x63,0x3f,0xd7,0x1f,0x26,0x86,0x2a,0x9a,0xa8,0xfc,0xff,
  0xfc,0x7e,0x04,0x87,0x97,0x91,0xc3,0xc3,0x22,0xee,0xd7,0xeb,0xe6,0x45,0x67,0xf8,
  0x41,0xea,0xf7,0x6e,0x7c,0xe2,0xee,0x9f,0x39,0xcb,0xbc,0x0f,0xfb,0x12,0xd5,0x68,
  0xf6,0x16,0xc8,0x51,0x70,0x83,0x16,0x6e,0x04,0xe5,0x89,0xc3,0x93,0x0c,0x75,0xa4,
  0x19,0x89,0xbc,0xae,0x0d,0x1b,0xf7,0x7e,0x0e,0xe3,0x92,0x59,0x69,0xc0,0x0a,0x24,
  0x3c,0x13,0x3d,0xd3,0xbc,0x0d,0x03,0x45,0x59,0x73,0x18,0xea,0xdb,0xe6,0xbc,0x85,
  0x42,0x81,0xc2,0xee,0x29,0x47,0xf2,0x09,0x0a,0xbc,0x24,0xf2,0x88,0xcc,0xca,0xe7,
  0x04,0x51,0x54,0x6b,0x53,0x73,0x7c,0x6b,0xaf,0x81,0x25,0x50,0x59,0x30,0x2e,0xdf,
  0xe0,0x5a,0xf8,0x96,0xf1,0xf8,0x7a,0x38,0xec,0x75,0x7d,0x5a,0x78,0xe4,0x2c,0x73,
  0x68,0x6a,0x27,0xf1,0x20,0xc0,0xf8,0x96,0xd0,0x00,0xc7,0xb5,0x3d,0xf0,0x8c,0x54,
  0xb2,0x90,0xd4,0x88,0x03,0x68,0x6b,0xbf,0x28,0xa7,0x24,0x0b,0x7b,0x8b,0x22,0x2d,
  0x7c,0xc6,0x77,0x84,0xe7,0x97,0xcc,0x1e,0x3c,0xa8,0x46,0xd9,0x83,0x51,0x31,0x1f,
  0x04,0x98,0xc4,0xf9,0x53,0x0d,0x43,0x42,0x07,0x30,0x8a,0x91,0x70,0x91,0x13,0xd8,
  0xe4,0x40,0x90,0x44,0x36,0x0e,0x0f,0xe8,0x72,0x89,0xa6,0x88,0x78,0xb0,0x87,0x14,
  0x97,0x78,0xdb,0xbc,0x50,0x25,0xc6,0x79,0x78,0x97,0x2b,0x15,0xbf,0x69,0xce,0x70,
  0x23,0x8e,0x2c,0xc7,0xd0,0x13,0xae,0x3b,0x3b,0xf9,0x59,0x94,0x7b,0x0b,0x90,0x2a,
  0x00,0xac,0x50,0x0c,0xf8,0xb2,0x81,0xf7,0x65,0xff,0xae,0x70,0x2d,0xcf,0xd9,0x66,
  0xc7,0x99,0xf5,0x2c,0x46,0x3a,0xc9,0x5b,0x62,0x65,0x28,0xfb,0x43,0x30,0xc9,0xcc,
  0x2b,0xd9,0x72,0x65,0x13,0xba,0x42,0x83,0x00,0xbe,0xd4,0x8a,0xcd,0x5b,0x1b,0xb0,
  0x15,0x3a,0x46,0xa3,0x1b,0x1b,0x62,0x43,0xc2,0xc7,0x45,0x0e,0x0a,0x1b,0x48,0xcb,
  0xdf,0x97,0x23,0x02,0x0b,0x08,0x73,0x7b,0x4c,0xa2,0xf8,0xa2,0x00,0x44,0xde,0x8c,
  0x24,0x40,0xa1,0x7c,0x98,0x55,0x36,0x60,0x2b,0xbc,0x0f,0x60,0xeb,0x3a,0x14,0x66,
  0x0c,0x6d,0x59,0xd7,0x68,0x74,0x29,0x84,0x0d,0xf8,0xaa,0x08,0xda,0xd1,0x54,0x63,
  0x5b,0x68,0x26,0x96,0xc2,0xa5,0x68,0x0a,0x23,0xdc,0xed,0x44,0x2e,0xec,0xbf,0x8c,
  0xca,0xb0,0x83,0x1f,0xa3,0x39,0xcd,0xdd,0xc1,0xe5,0x48,0xc8,0x1b,0xf5,0x10,0x03,
  0x1a,0xc7,0xc4,0x2e,0xe8,0x6a,0x24,0x68,0xa2,0x45,0x01,0x0c,0x3d,0xbc,0x0c,0x81,
  0x28,0x40,0xd7,0x43,0x25,0x86,0x6b,0xc5,0x06,0x01,0x46,0xa0,0x20,0x3d,0xe0,0x1b,
  0xb0,0x14,0x21,0x44,0xf3,0x03,0x03,0x54,0x0f,0x46,0x76,0xd1,0x42,0x8b,0x40,0x02,
  0x06,0x7c,0xd4,0x0c,0xa0,0xfa,0x7f,0x82,0xa9,0x29,0xe4,0xff,0x18,0x67,0x0b,0x8a,
  0xfc,0xb2,0x37,0xec,0xf4,0xba,0xd2,0xa0,0xdd,0x22,0x7f,0x0b,0xfa,0x7c,0x61,0xa2,
  0xca,0xc8,0xb1,0x10,0xd7,0xeb,0xce,0xd6,0x22,0xe3,0x34,0x6c,0x00,0x1a,0xa9,0xf9,
  0x81,0x61,0x9a,0x67,0xc5,0x68,0x3c,0x3c,0x9e,0x71,0x70,0x43,0xa3,0x33,0x8b,0x57,
  0x9d,0xda,0x04,0x45,0x3b,0xf2,0x5a,0xc5,0x77,0x62,0xe0,0x8b,0x1e,0x97,0xec,0x50,
  0xc0,0x66,0x41,0x8f,0x66,0x96,0xeb,0x04,0x27,0x42,0x7e,0xe8,0xec,0x7d,0xf8,0x28,
  0xa8,0x90,0xdf,0xdf,0xe8,0x28,0x80,0xc3,0x98,0xd4,0x8c,0x3e,0x08,0x5a,0xd1,0x51,
  0xd3,0x89,0x8a,0xa4,0x7b,0xc3,0xe0,0xbc,0x22,0x35,0x3f,0x5b,0x2d,0x30,0x39,0xec,
  0x17,0x58,0x9a,0xc2,0x72,0xd3,0x88,0xc2,0x5a,0x34,0x3d,0xcb,0x9e,0x09,0xe9,0xda,
  0xa2,0x7c,0x2d,0xc9,0xf7,0xe8,0x28,0x6c,0xc0,0xc1,0x69,0x0e,0xaf,0x07,0xe8,0xd8,
  0xf8,0xac,0x63,0x3b,0xb0,0x85,0xe2,0xf7,0x4b,0x04,0xdf,0x05,0x4e,0x3a,0x94,0x84,
  0x87,0xd2,0x21,0xb3,0xd6,0xe3,0x5f,0xdb,0xaa,0x19,0xaa,0x0d,0x8e,0xe3,0x5c,0x37,
  0x26,0x6b,0x66,0x69,0xf3,0x10,0x81,0x75,0x04,0x18,0x61,0x92,0x80,0xe5,0xb6,0x48,
  0x62,0x39,0x27,0x8c,0x7b,0x94,0x03,0x1b,0x19,0x4f,0x56,0xc2,0xa6,0xb1,0x80,0x87,
  0x80,0xe8,0x4b,0xe3,0x2f,0xec,0x64,0x98,0x90,0xb6,0x46,0x62,0x7a,0xf5,0x7b,0x98,
  0x73,0x6e,0x04,0xfe,0xef,0xd7,0x1a,0xf9,0x13,0x5e,0x1a,0x68,0x01,0x11,0xd7,0x7f,
  0xbb,0x87,0x9e,0xc4,0xa1,0xdc,0x8f,0x3a,0xb9,0x26,0xae,0x43,0xd0,0xb5,0xe1,0x03,
  0xe7,0x62,0xed,0xe5,0x28,0x7b,0x38,0xd6,0x82,0x2e,0x65,0x5c,0xc0,0xf1,0xa6,0x6d,
  0xd8,0x72,0x8d,0x37,0x75,0x05,0xc0,0x8f,0x5b,0x74,0x60,0xa4,0x72,0x8a,0x51,0x8b,
  0xa5,0xc0,0x96,0xba,0xe8,0x9c,0xb4,0xfb,0x03,0xe9,0x8d,0xd4,0xe9,0x5e,0x5d,0xfb,
  0x62,0xbf,0xfa,0x72,0x75,0xeb,0x7c,0x22,0x49,0x99,0x20,0x5d,0x66,0xda,0x1f,0xe2,
  0x61,0x8d,0x3a,0xc6,0xbd,0x13,0x61,0x3d,0xb1,0xc3,0xa9,0x0a,0xd9,0x47,0x3c,0x76,
  0x49,0xf6,0x04,0xc0,0x13,0x21,0xbc,0xc8,0x8d,0x87,0x9d,0x1a,0x62,0x3d,0xce,0x4c,
  0x07,0xe8,0x98,0x2a,0x2f,0xf6,0xe3,0x71,0x07,0x53,0x2c,0x9f,0xe3,0xb9,0x07,0x15,
  0x01,0x0d,0x3d,0x87,0xdd,0x05,0xcc,0x90,0x18,0x19,0x89,0x54,0x71,0xc8,0x43,0xae,
  0xc4,0x78,0xc8,0x61,0x81,0xe0,0x0f,0x65,0xb3,0xe5,0x38,0xc4,0xe5,0x90,0xf0,0x3c,
  0x23,0x46,0x59,0x93,0xd4,0xdc,0x70,0x90,0x28,0x5e,0x9c,0xbe,0xf0,0xbc,0xbd,0x94,
  0x11,0x03,0x13,0xd4,0x68,0xb9,0x53,0x8d,0xa4,0x47,0xf8,0x07,0xa1,0xe4,0x11,0x91,
  0xfb,0x48,0xca,0x0e,0x4d,0x01,0x11,0x58,0x7d,0xd8,0x3b,0x3b,0xbb,0x68,0x8b,0x8a,
  0xc3,0x31,0x67,0xb3,0xe7,0xcf,0x38,0x2a,0x16,0x2c,0xb0,0x20,0x9a,0x0f,0x00,0x78,
  0x1d,0x0e,0x3c,0x50,0xe6,0x2f,0x17,0x3d,0x7b,0xa6,0x18,0x75,0x82,0x1e,0x30,0x45,
  0x00,0x96,0x44,0xb6,0xe2,0xda,0x0b,0x3b,0xb0,0x63,0x52,0x0e,0x86,0x35,0xcb,0xd9,
  0xc6,0x7a,0x73,0xd0,0x22,0x66,0xbf,0x89,0x82,0x37,0x2a,0x30,0x14,0xd8,0x84,0xa2,
  0xb1,0x51,0xb4,0xdd,0xb1,0x13,0x1d,0x6a,0x32,0x01,0x50,0x16,0x4e,0x84,0xca,0xa1,
  0xb3,0xcc,0x70,0x56,0x86,0x88,0x21,0x32,0x4c,0x89,0x47,0xec,0x09,0x4b,0x47,0xe0,
  0x43,0x49,0x56,0x1b,0xcf,0xb5,0xf1,0x57,0x6d,0xf2,0xdf,0x9c,0x3c,0xb1,0xd2,0x7f,
  0x63,0x4c,0x23,0x0e,0x24,0x9f,0xb5,0xb7,0xa5,0xc8,0x27,0x34,0x94,0x7e,0x4b,0x63,
  0x2e,0x59,0xa6,0xbe,0xf9,0x90,0x8f,0x31,0x60,0x42,0xc9,0x40,0x13,0x27,0xb6,0x4a,
  0x86,0x72,0x84,0x7e,0xf6,0x6f,0x84,0xce,0x65,0xfb,0xa2,0x79,0x35,0x10,0xf7,0xc2,
  0xcf,0x8e,0x31,0xa0,0x46,0x7a,0x62,0x1b,0x60,0x6b,0x3c,0xba,0xd5,0xbb,0xc0,0x61,
  0x3a,0xc7,0xfe,0x5d,0x07,0xb8,0x19,0xea,0xca,0xd6,0x47,0x30,0x73,0x16,0x8a,0x7c,
  0x95,0x5a,0xd8,0x92,0xbb,0x72,0xb8,0x39,0x77,0x45,0x30,0x5a,0x90,0x99,0x5e,0x18,
  0xd1,0x2c,0x26,0x8a,0x68,0xc6,0xe6,0xb2,0xbc,0x3a,0xc1,0x32,0x9c,0x0c,0x13,0xa0,
  0x72,0x82,0x64,0x98,0xfd,0x84,0xc9,0x30,0xc2,0x51,0x5f,0x60,0x10,0x29,0xaf,0x5a,
  0x28,0x4c,0x05,0x6c,0xdc,0xd9,0x4a,0xf9,0xe2,0xbe,0xcd,0xe8,0x86,0xe9,0xe5,0xa0,
  0x56,0xad,0x85,0x6a,0x84,0x0d,0x3a,0xf7,0xb8,0xa8,0x12,0x1e,0x20,0x6f,0xae,0x34,
  0xbf,0xef,0x12,0x81,0x65,0x38,0x52,0xb4,0x01,0x90,0x0f,0x5d,0xb2,0x22,0x96,0x09,
  0x7b,0x40,0xa3,0xb9,0x13,0xa1,0x5e,0x98,0x7e,0xec,0x3b,0xb3,0x12,0x14,0x18,0xcb,
  0x29,0x08,0x34,0xa7,0xe8,0x06,0x4f,0x7e,0xc7,0xea,0x82,0x7b,0x48,0x3f,0x38,0x95,
  0x82,0x12,0x23,0x2e,0x6e,0x1e,0x99,0xe7,0xc9,0x6c,0x04,0x92,0x67,0xa7,0x90,0x73,
  0x44,0xee,0xa8,0x31,0x07,0x68,0xdf,0x77,0x66,0x1f,0xef,0x15,0xf9,0x24,0x40,0xfb,
  0x7d,0xbb,0xeb,0xcf,0x27,0xd0,0xee,0x80,0x5e,0x26,0xa6,0x79,0x47,0x9f,0x44,0x45,
  0xa4,0x75,0x04,0x72,0x77,0x23,0xf3,0xde,0x00,0xec,0x18,0xb8,0x3a,0xd1,0x09,0x32,
  0x65,0xb3,0xb0,0xcc,0x10,0x6d,0x07,0x92,0x6e,0xb4,0xe1,0x18,0x0a,0xc6,0x4a,0x7a,
  0x16,0x43,0x53,0xb9,0xd3,0x08,0x2d,0x37,0xd5,0x0d,0x23,0xbb,0xd0,0x97,0x0b,0xf5,
  0x21,0x5d,0xc0,0x3c,0xe0,0x2c,0xf8,0xce,0x99,0x8c,0xe0,0x34,0xe2,0x24,0x30,0x63,
  0x29,0x32,0x5d,0x29,0xa4,0x0a,0x91,0x34,0x81,0xa3,0x8c,0x6d,0x72,0x32,0x2c,0x25,
  0xd8,0x90,0x5c,0x3a,0x24,0x34,0x72,0xab,0x51,0x26,0xee,0x7e,0xc6,0x83,0x47,0x32,
  0x1e,0x44,0x6f,0xc1,0x5e,0x01,0xc3,0x03,0xe6,0x30,0x76,0xad,0xbc,0x57,0xaa,0x9b,
  0xa3,0x2f,0xf8,0x60,0xaa,0x83,0x3e,0xc5,0xa1,0x03,0x56,0x2b,0xd0,0x0a,0x28,0x5f,
  0x43,0x59,0x67,0x81,0x77,0x9a,0x2e,0xa0,0x74,0xa2,0xe0,0xef,0x80,0xce,0x24,0xad,
  0xc0,0xf5,0x21,0x15,0xbf,0x24,0x67,0xf2,0x52,0xc8,0xec,0xcf,0x6f,0x58,0xf0,0x28,
  0x55,0x43,0x07,0xd1,0x97,0x53,0x73,0x2d,0x86,0x04,0x0e,0xb8,0x13,0x11,0xcf,0x42,
  0x1b,0xb8,0xcf,0x03,0x2a,0x8d,0xd6,0x21,0xff,0x25,0xca,0x60,0xe7,0x1b,0x00,0x17,
  0x39,0xe2,0x5c,0x2b,0xb8,0xee,0x64,0xfa,0xee,0x43,0xcd,0x30,0x74,0x90,0x42,0x76,
  0xf0,0xa0,0x9f,0xa2,0xa1,0x8e,0x1d,0x3b,0xbc,0xf7,0x84,0xf0,0x4c,0x8d,0xc8,0x00,
  0xe9,0x80,0xf3,0x24,0x76,0x90,0xd4,0xac,0xfb,0x71,0x74,0x0b,0xa8,0x2d,0xd7,0xd8,
  0xb5,0x56,0xd8,0x44,0xf9,0x24,0x5b,0x50,0x50,0xd2,0x25,0x4c,0xbc,0x8f,0x0c,0x04,
  0x10,0xf8,0x13,0x6d,0x6c,0x5a,0x34,0x9c,0x26,0x78,0x63,0x1e,0x9f,0x87,0x0f,0x60,
  0x5d,0xbc,0x5f,0x99,0xff,0x19,0x3e,0x9e,0x11,0x80,0x33,0x4a,0xc4,0x78,0xfe,0xc1,
  0x11,0xb6,0xbb,0xfe,0x64,0x00,0xc3,0x54,0x27,0x40,0x35,0x4b,0xa3,0xd9,0x49,0x61,
  0x1a,0x07,0x22,0x6b,0x01,0x3f,0xa7,0x39,0x18,0xfa,0xdd,0x1c,0x8c,0xf0,0xc0,0x1e,
  0x5e,0x8b,0xe7,0xa1,0xf4,0x8e,0x0a,0x17,0xb4,0x55,0x37,0x6f,0x8b,0x7c,0xdc,0x90,
  0x31,0xb9,0xd9,0x39,0xa0,0xa4,0x0b,0x13,0xd3,0xcd,0x97,0xc4,0x5b,0x15,0x85,0xca,
  0xa6,0xb4,0xa2,0x24,0x46,0x27,0xe1,0x19,0x9f,0x02,0x16,0x2e,0xd1,0x54,0x85,0xb4,
  0xa9,0x92,0xa2,0x44,0xdc,0xed,0x40,0xed,0x56,0x2c,0xb3,0xbb,0x1d,0xe3,0xac,0xef,
  0x68,0x27,0xda,0x88,0xf6,0xe5,0xc5,0xd8,0x30,0x57,0x0c,0xdd,0x4a,0x6e,0x52,0x8c,
  0x79,0xeb,0xf8,0x12,0x61,0x78,0x8b,0xf5,0xd4,0x32,0x17,0x71,0xfe,0x80,0xeb,0xc7,
  0x3d,0x39,0x66,0x74,0x3b,0xc5,0x6b,0x54,0x78,0xc2,0x73,0x5e,0x1e,0x51,0xf5,0x25,
  0x93,0x4b,0xfc,0x31,0xcb,0x7a,0x0e,0x59,0x1a,0xc8,0x46,0x30,0x9d,0x08,0xfe,0x09,
  0x8b,0x2e,0x57,0x9c,0x56,0x13,0xc6,0x4b,0x36,0x46,0xdf,0x60,0xe0,0x89,0x0e,0x62,
  0xda,0x4b,0xde,0x2d,0x44,0x71,0x14,0x57,0x4a,0xdc,0xfa,0x08,0xa7,0xec,0x35,0xaf,
  0xa4,0xcb,0xde,0x49,0x5b,0xea,0xf6,0x86,0x3e,0x57,0x45,0x5d,0x5d,0x9a,0x13,0xad,
  0x6b,0x3a,0xb1,0xc9,0x55,0x01,0xff,0x4e,0xa9,0x44,0xb8,0x11,0xa1,0x78,0x5e,0x30,
  0xa4,0xc2,0x82,0x80,0xa1,0xdc,0x87,0x97,0x85,0x98,0x8a,0x4c,0xea,0x45,0x18,0x39,
  0x21,0x42,0x96,0x82,0xc9,0x3d,0xec,0x14,0xe9,0xa4,0xf3,0xbe,0xe3,0xbf,0xa4,0xc5,
  0xb9,0x00,0x8c,0xca,0xd5,0x3a,0xd9,0x5e,0x8a,0xbc,0x7b,0x53,0xca,0x44,0xe6,0x45,
  0x71,0x73,0x32,0x42,0xfe,0xd0,0x5d,0xad,0xd4,0x93,0x5f,0xc8,0x11,0x50,0xe5,0xf9,
  0xa9,0x59,0xff,0xc3,0x50,0x1a,0x06,0xd3,0x33,0x09,0x58,0x29,0x74,0x56,0x20,0x1d,
  0xf7,0x7e,0xf3,0x67,0x7c,0xaa,0x54,0x0e,0xbe,0xc4,0xc9,0xdc,0x9c,0x11,0x43,0x65,
  0x5b,0x31,0x64,0xbd,0xb2,0xa3,0x00,0x36,0xe8,0xc6,0x23,0x9e,0x90,0xa1,0xbf,0x5f,
  0x7d,0xe1,0x61,0x5c,0x31,0x79,0xc2,0x74,0xd1,0x8f,0xdb,0x9d,0x9a,0xe4,0xf0,0xa9,
  0x90,0x2f,0x46,0x87,0xdd,0x02,0x98,0xe4,0xf2,0x4a,0x11,0xd9,0xf7,0xed,0x1e,0xbb,
  0x49,0xfc,0x76,0x8f,0x55,0x13,0x40,0xaf,0xe8,0x68,0x87,0x16,0x17,0xd0,0xac,0x23,
  0xe0,0xad,0xb7,0x20,0x2b,0xa4,0xb1,0xa1,0xda,0x76,0x23,0xc5,0x6f,0xdb,0xa5,0xf0,
  0x05,0xbc,0xb2,0xef,0x66,0xfc,0x95,0x7b,0xa9,0x2e,0x25,0x61,0xbd,0x81,0x63,0xf3,
  0xa1,0x91,0x42,0x53,0xb4,0x84,0xff,0xa5,0x24,0x34,0xae,0x1b,0x29,0x14,0x01,0x29,
  0xe9,0x61,0x61,0x2c,0x6d,0x7a,0x87,0xba,0xb6,0xb7,0x77,0x7f,0x7f,0x9f,0xbf,0x2f,
  0xe5,0x4d,0x6b,0xb6,0x57,0x04,0xc1,0x8f,0xe5,0x03,0x18,0x78,0x18,0x00,0x53,0x5f,
  0x69,0xf0,0xa1,0x91,0x42,0x30,0x94,0xc9,0xe8,0x67,0x0b,0x46,0x28,0x72,0xc8,0xec,
  0x7a,0x73,0x6a,0xcf,0xdf,0x15,0x9a,0x94,0x52,0xd2,0x63,0x23,0x75,0x98,0xe2,0x60,
  0x8a,0x65,0x0f,0x4c,0xa1,0x12,0x00,0x43,0x11,0xb4,0x1d,0xcb,0xfc,0xaa,0x21,0x50,
  0x72,0x49,0x97,0x3f,0xc8,0x31,0x08,0x40,0x65,0x61,0x9c,0xb1,0x6e,0x8d,0x0d,0x4d,
  0x1a,0x03,0x98,0xc2,0x7e,0x4a,0x1a,0xc3,0x60,0x85,0x03,0x00,0xdb,0x48,0xed,0x3f,
  0x0f,0x6a,0x22,0x98,0xc5,0xfc,0xbe,0x37,0x65,0x72,0x41,0x38,0x51,0xb7,0xc2,0x76,
  0x3a,0xc1,0x43,0x24,0x54,0xc5,0x25,0x54,0xc5,0xa3,0x53,0x99,0x92,0x49,0x80,0x42,
  0xa7,0x10,0x39,0x34,0x12,0x98,0x0c,0x5d,0xa4,0x43,0x0b,0x18,0x4f,0x71,0xda,0x4c,
  0x71,0x36,0x52,0xf9,0x8a,0x00,0x00,0x23,0xf9,0xd2,0x43,0x81,0xae,0x57,0x81,0x2c,
  0xd8,0x43,0xb1,0x91,0xaa,0xc2,0xb7,0x22,0xf9,0xb6,0x85,0x7c,0x00,0x4c,0x80,0x5c,
  0x8e,0x82,0x5c,0x2c,0xfa,0x40,0x17,0x0f,0x5e,0x09,0xfb,0x2d,0xf2,0x2a,0xfb,0x28,
  0x6c,0x12,0xf7,0xa2,0xa5,0xc7,0xc6,0x78,0x8c,0xe7,0xbe,0x2e,0xa4,0x8e,0xce,0xc1,
  0x03,0x18,0x99,0x8f,0xb2,0x2d,0xdd,0xa8,0xce,0x78,0x3e,0x34,0xef,0x35,0x0b,0xa0,
  0x41,0xab,0xe8,0x2e,0xc5,0xd4,0xd1,0xd6,0x42,0x09,0xd2,0x9b,0xd1,0xad,0x61,0xd4,
  0xa5,0x3b,0xf0,0xc5,0x44,0x58,0x6f,0xf7,0x00,0xb7,0x30,0x96,0xde,0x75,0x4d,0x0f,
  0x4d,0xe1,0x35,0xbf,0xfd,0x98,0x92,0xf4,0x09,0xfd,0x76,0x02,0x5f,0x8e,0x44,0x60,
  0xc2,0x47,0x11,0x59,0x76,0x4f,0x2e,0x75,0xd4,0x1e,0x5c,0x95,0x8a,0xb9,0x56,0xf3,
  0x12,0xeb,0x3c,0xf4,0xde,0x17,0x2b,0x65,0x01,0x2f,0xb7,0xf7,0xdb,0xa5,0xca,0xa1,
  0x50,0x6b,0x9d,0xc3,0x71,0xd4,0x91,0x44,0xcd,0x26,0x20,0xfe,0x72,0x6c,0xe8,0xe3,
  0xaf,0x8d,0x94,0x3d,0x37,0xef,0x87,0xea,0x28,0x2d,0x63,0x62,0xaf,0x9c,0x75,0xe6,
  0xba,0x9d,0x49,0x1d,0xbd,0xf9,0xf9,0xb0,0xb2,0x5f,0xae,0x4b,0x17,0x9d,0xf7,0xed,
  0xb7,0x7b,0x14,0xcc,0x26,0x98,0x74,0x42,0x34,0x27,0x1c,0x20,0x1d,0x3b,0xcb,0x28,
  0xf0,0xf4,0xbd,0x38,0xc0,0xc1,0x41,0xa5,0xce,0xc2,0x25,0x74,0xba,0x14,0x8c,0x73,
  0x8c,0x87,0x80,0xc8,0x30,0x20,0x47,0x1b,0xa9,0xe7,0xa5,0x4c,0xbf,0xec,0x54,0x55,
  0xcc,0xa0,0x46,0x5d,0x58,0xf1,0xf4,0x1a,0x3f,0x56,0x09,0x65,0x90,0x83,0xe7,0xe9,
  0xe8,0x63,0xd5,0x60,0x46,0xc2,0x02,0xbc,0x52,0x43,0xc3,0xe5,0x24,0xeb,0x21,0xd2,
  0xec,0xed,0x1e,0x59,0x10,0xaa,0x10,0x50,0x03,0xec,0xbc,0xfd,0x29,0x97,0x93,0xfe,
  0xfd,0x7f,0xff,0xcf,0xcb,0xfe,0x23,0x8b,0x22,0x0d,0x9b,0xc7,0xaf,0x00,0x91,0xcb,
  0x01,0x42,0xc8,0x9c,0x48,0x73,0x58,0x43,0x92,0xd6,0x9d,0xe2,0x8b,0xca,0xac,0x13,
  0xce,0x2c,0xac,0x29,0x7b,0xe9,0xde,0x84,0x83,0xe7,0x38,0x3b,0x9c,0xcb,0x45,0xfb,
  0x74,0x88,0xb1,0xef,0xeb,0xcb,0x2e,0x01,0x4d,0x39,0x9f,0xbc,0x67,0x2d,0x06,0x24,
  0x2f,0x9c,0xbd,0xf4,0x6f,0x0c,0x12,0x3d,0xe1,0x77,0xb0,0x28,0x33,0x79,0xb7,0xe5,
  0x22,0xb7,0x92,0x77,0xeb,0x87,0x72,0x6a,0xa9,0x48,0x39,0x55,0x3a,0x6d,0xb7,0x4f,
  0x84,0x5d,0xe4,0xef,0x25,0x5c,0x4f,0x11,0x47,0xb9,0xc1,0xef,0xbc,0x7d,0x64,0x0f,
  0x13,0xe5,0x97,0xd7,0xa1,0x07,0x5f,0xbd,0xf6,0x9b,0x7a,0x50,0xcd,0x0d,0xe8,0x15,
  0x8a,0xd5,0x62,0xf9,0xa0,0xee,0x43,0x2b,0xa6,0x9b,0x83,0x52,0xee,0x13,0x99,0x89,
  0xd4,0x3b,0x3d,0x25,0xe5,0x18,0xfe,0x88,0xee,0xcc,0x76,0xc8,0x0f,0x34,0x7e,0x31,
  0x64,0x9f,0x3a,0xba,0xea,0xb7,0x07,0x03,0xb4,0x26,0xfb,0x43,0xf0,0xac,0xa5,0x26,
  0x58,0xe1,0xef,0x9b,0xc3,0x76,0x00,0x89,0xe0,0x57,0x7d,0x31,0x13,0x88,0xd4,0x59,
  0xcc,0x22,0xb7,0x70,0x4a,0x52,0x0d,0x50,0x7f,0x17,0x78,0x8b,0x80,0xb6,0xdc,0x42,
  0x7b,0x7a,0x8b,0x65,0x1b,0xc1,0xbd,0xcb,0x27,0xe2,0x4a,0xe1,0x28,0x54,0x9a,0x10,
  0x36,0x39,0x38,0xe4,0x02,0x6d,0xfb,0x52,0x38,0xb6,0x08,0x68,0x68,0xb7,0x0d,0x9f,
  0xa8,0x0e,0x11,0x60,0x23,0xd7,0xb9,0x97,0x3f,0x28,0x3c,0xf8,0x1a,0xc0,0xa8,0xdf,
  0x6e,0x6d,0x66,0x59,0x72,0xe1,0x40,0xa4,0x10,0xb1,0xa8,0x8f,0x60,0x81,0x6a,0x6f,
  0xf7,0xe8,0x67,0xef,0x9d,0xad,0x19,0x68,0x79,0xb8,0x9b,0xd8,0x10,0xa7,0xd0,0xd7,
  0x6c,0x22,0x96,0xe7,0x98,0xd7,0x00,0x5b,0x88,0xfc,0x4d,0x77,0xe5,0xaf,0xb7,0x20,
  0xc3,0x9c,0xc7,0x74,0xc6,0x4f,0x65,0x73,0x45,0x84,0x00,0xd8,0xc9,0xb7,0x1a,0x5a,
  0x2a,0x47,0xbf,0xfe,0xfa,0xfe,0xac,0x29,0x15,0x2a,0xca,0x43,0xa1,0x08,0x8a,0x87,
  0xbe,0x8f,0xe9,0xb2,0x0f,0x5d,0xb0,0x47,0xa9,0xa8,0x3c,0x14,0xcb,0x49,0x7a,0x54,
  0x52,0x47,0xad,0xce,0xa9,0x04,0xf2,0xf5,0xa1,0x78,0x58,0x49,0xd0,0xe1,0x00,0x34,
  0x3f,0x0e,0x51,0xae,0x2a,0x0f,0xa5,0x44,0x48,0x81,0xf9,0x43,0xe9,0xa4,0x4d,0x8e,
  0xb0,0x27,0xe8,0xd0,0x07,0xe8,0x9d,0xa0,0xe7,0x21,0x98,0x0c,0xd8,0xa3,0x0a,0xd8,
  0x55,0x94,0x24,0x3d,0x0a,0x4a,0xea,0xe8,0x37,0x24,0x99,0x52,0x2c,0x3f,0x1c,0x54,
  0xaa,0x49,0xba,0xa0,0x61,0x42,0xfa,0x14,0x61,0x4a,0xd8,0x31,0x49,0xa7,0x52,0xea,
  0xe8,0xfa,0x37,0xba,0x36,0x64,0x71,0x22,0x90,0x03,0xc5,0x44,0xa6,0x1d,0xe2,0xa5,
  0xd3,0xab,0x67,0xf3,0xd2,0xe9,0xea,0x75,0xbc,0x04,0x8c,0xb1,0x2f,0x4d,0x57,0x76,
  0x32,0x12,0x7a,0xeb,0x55,0x50,0x92,0xf6,0x82,0x11,0x0a,0x49,0x87,0x28,0xc2,0x2a,
  0x15,0x37,0x40,0x0e,0x52,0x2d,0x6c,0xad,0x79,0x2a,0xae,0x85,0xa1,0x7b,0xd3,0xb0,
  0x13,0x28,0xb9,0x04,0x4a,0xad,0x5a,0x2d,0xd4,0xa5,0xde,0x55,0xbb,0xdf,0xc4,0x18,
  0xc8,0x60,0xa3,0x88,0xe0,0xf7,0x64,0x44,0x21,0xe1,0x37,0xd1,0xf0,0x94,0x72,0x26,
  0x9a,0x64,0x78,0x67,0x9e,0xae,0x56,0x5a,0x30,0xf5,0xa8,0xbc,0xa7,0x1a,0x54,0x34,
  0xf8,0x36,0x40,0xb4,0x7c,0x10,0xcd,0x95,0x0f,0x60,0x51,0x01,0xc1,0x76,0xde,0xbc,
  0x78,0x06,0xbc,0x91,0x00,0xcf,0x51,0xbf,0x6a,0x57,0x73,0xd3,0x31,0xd3,0x53,0xd5,
  0xb0,0x35,0x01,0xc9,0x56,0xf3,0x6a,0x78,0xdd,0x6f,0x27,0x82,0x48,0xb3,0x9e,0x23,
  0xc1,0x3a,0xd6,0x2d,0x83,0x5a,0xad,0x1e,0xba,0x50,0xa5,0x5d,0xe9,0xf4,0xa2,0x39,
  0x38,0x4f,0x04,0xdd,0x14,0x00,0x63,0x01,0x34,0x6b,0xf2,0x5e,0x9f,0x68,0x66,0xba,
  0xa0,0x64,0x7c,0xb2,0x1d,0x36,0xbf,0xfd,0x2a,0x80,0xa5,0x20,0xc0,0x52,0x42,0x80,
  0x78,0x2f,0x40,0x80,0x89,0x07,0xb3,0x74,0x91,0x6e,0xf4,0xe5,0xc4,0xbc,0x87,0xa5,
  0xe2,0x0a,0x9a,0x9c,0xe4,0xd1,0x03,0xbc,0x1a,0xb1,0xc4,0x8b,0x38,0x62,0x75,0xff,
  0xf0,0x90,0xb0,0x60,0x97,0x5a,0x23,0xed,0xdf,0x86,0xed,0x7e,0xb7,0x79,0x91,0x68,
  0x70,0x9a,0xfe,0xee,0x9b,0x12,0xe1,0x3b,0x70,0x61,0xb6,0x0f,0x5c,0x29,0xed,0xe3,
  0x54,0x8f,0x7b,0xbd,0xa1,0x34,0xf8,0x30,0x18,0xb6,0x2f,0x83,0x63,0xc6,0xed,0xc3,
  0x4b,0x92,0x91,0xfb,0xc2,0x5d,0xe8,0x4b,0x53,0xdf,0x60,0x9a,0x08,0x3b,0x95,0x4f,
  0x84,0x57,0xfc,0x62,0x06,0x9f,0x52,0x81,0x09,0xb0,0x5c,0xf8,0x93,0xf6,0x90,0xc6,
  0x31,0x83,0xe6,0x43,0x78,0xd4,0x80,0xf7,0x18,0x6a,0xe5,0xb9,0x8f,0xb4,0x43,0xd0,
  0x81,0x8c,0x70,0x74,0x59,0xfe,0xb3,0xd8,0xeb,0x82,0x3c,0x38,0x3a,0xe9,0x0c,0x9a,
  0xfd,0x4b,0xdc,0x9d,0xa2,0x97,0x9c,0xd4,0xac,0x11,0xf2,0xa6,0x9f,0x21,0x79,0x34,
  0x87,0x2e,0x8e,0xb0,0x01,0x89,0xf1,0x0e,0x88,0x3c,0x5f,0xe8,0xb8,0xc0,0x44,0x21,
  0x81,0xd0,0xe8,0xcc,0x62,0x58,0x26,0x9a,0xf8,0xd4,0xe9,0x09,0x19,0x5b,0x6e,0xc8,
  0x60,0x04,0x44,0x1b,0x68,0xe4,0x34,0xf9,0x0e,0x6f,0xbd,0xbd,0x59,0x8e,0xec,0x55,
  0xdd,0x47,0x6d,0x96,0xce,0xc7,0x74,0x25,0xb4,0x7d,0x0f,0x5b,0xf0,0x68,0x5f,0x71,
  0xbd,0xc2,0xa0,0x9a,0x25,0xf9,0x55,0xac,0x0a,0x28,0xc9,0x38,0xf5,0xba,0xb2,0x61,
  0x06,0x78,0xc4,0x02,0xf3,0x5e,0xe8,0x4b,0x12,0x2e,0x5a,0xa8,0x18,0x36,0x52,0x40,
  0x2d,0x72,0x65,0xaa,0xa4,0x84,0xc5,0x37,0x97,0x04,0x24,0x18,0xdd,0xe6,0xf8,0x76,
  0x01,0x2e,0x77,0x7e,0xa6,0x39,0x6d,0x43,0xc3,0x8f,0xc7,0x8f,0x9d,0x49,0x5a,0x66,
  0x68,0xc9,0x99,0x3c,0x46,0x54,0x5a,0xac,0x7e,0x29,0xba,0xe5,0x79,0x02,0x71,0x93,
  0x3d,0xce,0x33,0x25,0x81,0xe3,0xc8,0x64,0x2e,0x7a,0x37,0x7c,0x5a,0xe4,0xcf,0xf3,
  0xce,0xd9,0xb9,0x3b,0x4f,0x3f,0xa7,0x87,0xe8,0xe8,0xdf,0x36,0xee,0x8d,0x5b,0xb0,
  0xfe,0x4c,0xd3,0x00,0xd9,0xb4,0x94,0xd2,0x36,0x16,0x95,0x9c,0xd8,0x99,0x78,0x9a,
  0x2d,0x6f,0x31,0xff,0xd7,0x75,0x5c,0xe1,0x15,0x25,0xe0,0x98,0xc1,0xe9,0x60,0xdb,
  0x94,0x60,0xfb,0x11,0x32,0x16,0x19,0x19,0x4b,0x48,0x46,0x86,0x0a,0xbb,0x78,0x41,
  0xb0,0x48,0xaa,0xa7,0x6c,0xf5,0x4e,0xa3,0x3c,0x08,0x64,0x9c,0xea,0x33,0x41,0xb2,
  0x89,0x45,0x5e,0x82,0x93,0x14,0x96,0x8b,0x48,0x8b,0xc2,0xa1,0x02,0xea,0xb7,0x09,
  0xfe,0x2b,0x13,0x19,0xad,0x5e,0xf7,0xb4,0x73,0x26,0xec,0xc8,0x04,0xc2,0x8f,0x7e,
  0x22,0x02,0x50,0x5b,0x4e,0x24,0x8c,0x5b,0x48,0x54,0xb2,0x12,0x49,0xc8,0x3d,0xf5,
  0x3e,0xac,0xd2,0x16,0x57,0x7d,0xa8,0x2f,0x34,0xcc,0xe9,0xd1,0x5e,0x6d,0xc8,0x48,
  0x24,0x3b,0x9b,0x59,0x04,0xa5,0xba,0x97,0x85,0x17,0xde,0x8b,0x01,0x57,0xf1,0x65,
  0x39,0xa9,0x81,0x43,0xa6,0xc0,0x5a,0xba,0x31,0x26,0x9e,0xf7,0xe7,0x2e,0x56,0xe8,
  0x9c,0x21,0x75,0xd4,0xe9,0x12,0xb7,0xb7,0x1d,0x92,0x8e,0x3e,0x5e,0x76,0x4c,0xd8,
  0xeb,0x64,0xaa,0x8d,0x54,0x7b,0xa9,0x8e,0x0c,0x0d,0x26,0x66,0xe3,0xdf,0xf0,0x94,
  0x51,0xd1,0x2f,0xce,0x45,0xe6,0x25,0x69,0x95,0x23,0xf3,0x21,0xc5,0xb0,0x1a,0x92,
  0xd4,0x48,0xd1,0xb2,0x06,0x19,0xe7,0xae,0x46,0xd0,0xa4,0x16,0xe5,0x0e,0xcd,0xcb,
  0x74,0xa3,0x4f,0x02,0xe7,0xf8,0x36,0x8f,0x9f,0xec,0x61,0xe9,0xd6,0x41,0x2a,0xc2,
  0x5e,0xd9,0xb8,0xfb,0x12,0xed,0x3d,0xc7,0xe0,0x70,0xdc,0x8d,0x87,0x87,0x0b,0x3e,
  0x01,0x56,0xaa,0xe0,0xd6,0xdb,0x3a,0xd1,0x58,0x01,0x54,0xb0,0xa5,0xcb,0x4e,0xd7,
  0x27,0x83,0x10,0x2c,0x3c,0x6d,0xfe,0x16,0x25,0x88,0xbc,0x78,0x97,0xd1,0x05,0xc9,
  0xd7,0x59,0x4e,0xcd,0xd4,0x33,0x62,0x28,0x5b,0x72,0xa8,0xbc,0xa2,0x1a,0xe1,0x53,
  0xcd,0xa8,0x28,0xaf,0xb7,0xdf,0x6e,0xf4,0x53,0x5d,0x7a,0x23,0x0d,0xc1,0xd1,0x98,
  0x59,0xea,0x42,0x12,0x52,0xea,0xbc,0x1d,0xe8,0x17,0x44,0x81,0xd4,0x3e,0x2f,0xa4,
  0x4c,0xbf,0x79,0x16,0x2f,0xe1,0xa8,0x16,0x6d,0xad,0xa5,0x65,0x6c,0x22,0x67,0xfc,
  0x51,0x74,0x62,0x05,0x97,0x40,0x02,0x75,0xdb,0x43,0xe9,0x8d,0xba,0x58,0x81,0x3d,
  0xdc,0xbb,0xbc,0x1c,0x30,0x29,0x14,0x13,0x44,0x27,0xa9,0x84,0xae,0x6d,0xee,0x8f,
  0x90,0xfb,0x42,0xc6,0xbe,0xe8,0xa1,0x3f,0x5f,0x50,0x44,0x1d,0xbf,0x46,0x0b,0x9c,
  0x28,0x85,0x51,0x15,0x76,0xf7,0xdb,0x15,0x01,0xe3,0x9d,0x92,0x0b,0xa6,0x05,0x3b,
  0x51,0xff,0xf7,0xbf,0xfe,0x47,0x6a,0x23,0x5f,0x52,0x7a,0x8f,0x2d,0x6d,0x02,0x42,
  0x43,0x07,0xd3,0x41,0x72,0x4c,0x89,0x15,0x30,0xc6,0x8f,0x96,0x79,0x0b,0xad,0xf2,
  0x6f,0xf7,0x56,0x31,0x3b,0x85,0xc0,0x18,0x0c,0x3a,0x27,0x71,0x1b,0x84,0x9c,0x58,
  0x84,0xb6,0x07,0xce,0x15,0x7b,0xa6,0x24,0x90,0x74,0x63,0x6d,0x0e,0x8a,0x4a,0xb3,
  0x60,0x37,0x81,0x58,0x33,0xad,0xaf,0xa4,0xc0,0x78,0x6a,0xdb,0xc8,0x57,0xf0,0x1d,
  0x6f,0x1b,0xc5,0x8d,0xbe,0x62,0x6d,0xa2,0x31,0x40,0x08,0x01,0x0c,0xfe,0xfd,0xaf,
  0xff,0x17,0xf9,0x5f,0xe4,0x6e,0x64,0xe9,0x0e,0x01,0xf3,0x33,0x02,0x5f,0x97,0xad,
  0x8f,0xc1,0x98,0x1f,0x9a,0x5f,0xb5,0xe5,0xcb,0x90,0x06,0xa1,0x4e,0x7a,0x07,0x90,
  0x06,0xa8,0x9f,0x87,0xbd,0x5f,0xda,0xdd,0x54,0x12,0x1c,0x5a,0x73,0xd5,0x91,0x5e,
  0xb2,0x68,0x20,0xa7,0x9c,0xd0,0x92,0xe1,0xc3,0xcf,0x82,0xe7,0xcd,0xb8,0xd0,0x99,
  0x05,0xd4,0x4b,0x12,0xe1,0x52,0x8d,0x13,0x2e,0x24,0x09,0x43,0x91,0x94,0x8d,0xc2,
  0xc5,0x63,0xd5,0xed,0x06,0x4b,0xcb,0xe3,0xfc,0xed,0xf6,0x4a,0xd1,0xa7,0x42,0x03,
  0xd6,0x0a,0x15,0x16,0xd4,0x4f,0xdb,0x89,0x32,0x55,0x62,0xa3,0x25,0xc0,0xe7,0x96,
  0x2a,0x0d,0x60,0x46,0x30,0x15,0xfb,0xc5,0x52,0x0f,0x53,0x8b,0xc9,0x97,0x68,0x09,
  0xb1,0x59,0x16,0x42,0xc7,0x28,0x51,0x78,0x50,0xac,0xc2,0xf4,0xda,0xdd,0x41,0xaf,
  0xff,0x67,0x4a,0x40,0x32,0x0d,0x2a,0x00,0x3d,0x6e,0x72,0x25,0x60,0x20,0x7b,0x1a,
  0x34,0xf5,0x65,0xf3,0xac,0x8d,0xf8,0x0d,0xfb,0xbd,0x8b,0x81,0xc8,0x00,0x5b,0x4d,
  0xb5,0xc8,0x1d,0x72,0x4c,0x12,0xe1,0x96,0x9a,0x6d,0x4b,0x9b,0x1d,0x9a,0x3b,0xda,
  0x2a,0x75,0xf4,0x2c,0x7f,0x86,0xe8,0x7d,0x85,0xe9,0xfd,0xb2,0x6b,0x12,0x14,0x99,
  0xa7,0xc3,0x60,0x3e,0xcb,0x85,0x61,0x88,0x04,0x5c,0x98,0xb4,0xe7,0xc3,0xe4,0xb0,
  0xec,0x80,0xba,0x00,0x6f,0x0d,0x5a,0x8f,0xdc,0xb9,0xd1,0xd3,0x47,0xb7,0x49,0x52,
  0x4f,0x27,0x57,0xf4,0x19,0x19,0x8a,0xef,0xdb,0x6e,0xf1,0x15,0x4e,0x4f,0x95,0xfa,
  0x3c,0x34,0xe5,0x37,0x8e,0xf2,0xbc,0xcd,0x8f,0xa5,0xbd,0x0b,0xf5,0x79,0xd4,0xe7,
  0xdd,0x12,0xd2,0x9f,0xa7,0x34,0xff,0x35,0xa9,0x3f,0x00,0x51,0x4d,0xf3,0x6c,0xe3,
  0xe8,0x0f,0xad,0x7e,0x2c,0xe9,0x11,0xe0,0xf3,0xa8,0x0e,0x3d,0x12,0x12,0xdc,0x76,
  0xa7,0xf4,0x17,0x25,0xf9,0x5c,0xb5,0x56,0xdb,0x64,0x0d,0x69,0xf4,0x83,0x69,0x4e,
  0x40,0x3e,0x93,0xea,0xd8,0x27,0x29,0xdd,0xf9,0xbc,0xfe,0xa2,0x64,0x5f,0x69,0x63,
  0xd0,0xfa,0x52,0x7b,0x3a,0x05,0x65,0xb2,0xed,0xc8,0xc7,0x35,0x7d,0x6c,0xda,0xde,
  0x77,0xe0,0xe3,0xce,0x98,0x82,0xfc,0xac,0x91,0x26,0xe2,0xb4,0x63,0xcf,0x7f,0x94,
  0xd4,0x51,0x97,0x5c,0x85,0x72,0x0f,0x5c,0xc2,0x87,0x8d,0x5d,0x6d,0x46,0xae,0x90,
  0x26,0x39,0xc0,0x49,0x1d,0x9d,0x59,0xda,0x23,0xa1,0xe7,0x26,0x88,0xa5,0xd4,0x51,
  0x5f,0x9b,0x48,0x43,0x7d,0xe9,0x24,0x80,0x58,0x26,0x10,0xb5,0xa5,0xbf,0x7d,0xf8,
  0x14,0xeb,0x18,0x3e,0x24,0x85,0x59,0xc1,0xe8,0xe1,0x4a,0x57,0x13,0x1f,0x32,0x25,
  0xb1,0x03,0x6e,0xce,0x3b,0xc3,0xb6,0x74,0xdc,0x24,0x49,0x4c,0xcf,0x35,0x03,0x84,
  0x36,0xde,0xb5,0xe0,0xd8,0x20,0x03,0xbb,0xb9,0x99,0x3a,0x6a,0x62,0xcd,0xe6,0x1b,
  0xbc,0xa5,0x21,0x1d,0xab,0x86,0xba,0x1c,0x6b,0xc1,0xd0,0x43,0x54,0xa8,0xe4,0x28,
  0x2e,0xfc,0xd1,0xbc,0x39,0x06,0xbb,0x9b,0xde,0x34,0x8d,0xe2,0x35,0x72,0x27,0x64,
  0xa4,0x1a,0x8c,0xcb,0x58,0xcb,0x77,0x85,0x1a,0x9e,0x8f,0xc4,0x45,0x43,0xc2,0x9c,
  0xbe,0x39,0x10,0xff,0x6c,0x3a,0xdc,0x1c,0x4b,0x67,0xaa,0xbe,0xfc,0x11,0xb3,0x3f,
  0x8b,0x9d,0xbe,0x7a,0x3f,0xfa,0x3c,0x83,0x91,0x7e,0xfc,0xf4,0x23,0x7c,0xcc,0x63,
  0x09,0x1d,0xe9,0xe4,0x22,0xe2,0xe6,0x18,0xdb,0x47,0x8a,0x08,0x40,0x7b,0x01,0xef,
  0x9e,0x23,0x1b,0x90,0xb9,0x62,0x24,0xc3,0xe0,0x76,0xb9,0x7c,0x4c,0x26,0x16,0x5a,
  0x86,0x79,0x3b,0x79,0x8c,0x91,0x09,0xbd,0xe9,0x54,0x1f,0x6b,0xc9,0x24,0xc2,0xb9,
  0xb9,0xd0,0x7e,0xe8,0xe6,0x6d,0xff,0x76,0xd5,0x1b,0xe0,0xb9,0x23,0x75,0xa4,0xce,
  0x9a,0x18,0xcd,0xfa,0x73,0xb7,0x70,0xfb,0x61,0x65,0xda,0xb7,0x96,0x26,0xa5,0x9b,
  0xed,0x56,0xe6,0xf5,0x5c,0xdc,0x6e,0xc5,0x32,0xb1,0xc6,0x86,0xfb,0x3c,0x76,0xac,
  0xbf,0xd6,0x46,0xee,0xa2,0x8f,0x40,0xb8,0x9e,0x90,0xa2,0xf8,0x43,0x68,0x51,0x8c,
  0xdc,0x11,0xaa,0x36,0x2e,0xfe,0x19,0xbb,0xb8,0x09,0x0e,0xa2,0xb9,0x58,0x69,0x4b,
  0x7b,0xab,0x79,0xdb,0x6c,0x5f,0xfc,0x58,0x53,0x0b,0x01,0x3e,0xcf,0xd0,0x82,0x1e,
  0x09,0xcd,0x2c,0x55,0xfb,0x6c,0x68,0x77,0x9a,0xf1,0xd7,0xb4,0xb2,0x2e,0xd5,0xe5,
  0x2d,0x1a,0x59,0x7c,0x63,0xc5,0x52,0xbd,0xf5,0x3e,0x75,0x54,0x52,0x5e,0x4e,0x78,
  0x4c,0xf5,0x11,0x82,0xec,0x8a,0x4b,0x7d,0x00,0xfc,0x5c,0xf2,0xb7,0xde,0x6f,0x3c,
  0x12,0x14,0x69,0x3f,0xfe,0x4c,0x1e,0x6d,0x92,0xe7,0xb1,0xa4,0xf7,0xd3,0x9a,0xe6,
  0x29,0x45,0x52,0x3b,0x7a,0x23,0x47,0x90,0xbc,0x12,0x38,0x4f,0x8b,0x97,0x76,0xa8,
  0xa9,0x61,0x7b,0x9f,0xfd,0x08,0x49,0x77,0x16,0x2f,0xe9,0x50,0x55,0xff,0x87,0xa4,
  0x5c,0x78,0xa7,0x33,0x9e,0x23,0xd3,0x8b,0xe3,0xb7,0xb3,0xd6,0xd9,0x6b,0xb6,0x79,
  0xc9,0xe3,0x35,0x97,0xd3,0x10,0xe4,0x33,0x39,0x0d,0xba,0x24,0xe1,0xb4,0xd9,0x58,
  0xb4,0x77,0x5e,0xc3,0x68,0x25,0xe5,0xb5,0x9b,0x9a,0x50,0xb6,0xa5,0xe9,0x86,0xbe,
  0x9c,0x25,0xb7,0x8a,0x90,0x45,0x36,0xb0,0xc6,0x98,0xc2,0x7a,0x8e,0x55,0x54,0x7c,
  0x88,0xb1,0x89,0xca,0x1b,0x5f,0x82,0x15,0x54,0x7d,0x48,0x60,0xe0,0x80,0x31,0x54,
  0xa8,0x6c,0x84,0x02,0xe6,0x4f,0x69,0x33,0x02,0xe0,0x09,0x55,0xca,0x0f,0xc9,0x7c,
  0xa0,0x42,0x31,0x0a,0x9d,0x57,0x58,0x51,0xad,0x5e,0xbf,0x4f,0x13,0x6c,0x06,0xcc,
  0x90,0xea,0xf5,0x3b,0xed,0xee,0xb0,0x49,0x73,0x6e,0xfe,0x34,0x7b,0xea,0xd8,0x50,
  0xc7,0x5f,0xa5,0x2b,0xfd,0x01,0x58,0xaa,0x65,0x5a,0xec,0x27,0x06,0x5e,0x2d,0x68,
  0x8e,0xaf,0xa2,0xb9,0x68,0xb4,0x1a,0xff,0xa5,0x0c,0x28,0xea,0x0c,0xfe,0xf0,0xe9,
  0xdf,0x5c,0xc5,0xcb,0xd9,0xfb,0xbf,0x18,0x19,0x2e,0xc0,0xdc,0xfa,0x91,0xf3,0xbf,
  0x68,0x77,0xe3,0x09,0x60,0x68,0xcb,0xbf,0x16,0x05,0xce,0x4d,0x4b,0xff,0x86,0x77,
  0x44,0x0c,0xe9,0x52,0xb7,0x2c,0xd3,0x7a,0x35,0x0d,0xce,0x2f,0x3b,0xfd,0xc8,0x3d,
  0x30,0x5f,0x90,0x01,0xfe,0x52,0xd3,0x7f,0xcf,0xee,0x05,0x49,0xa7,0x86,0xbe,0x7a,
  0xf5,0xd4,0xdf,0x9f,0x5e,0x74,0xae,0x22,0xe7,0x7e,0x37,0x05,0xf8,0x7f,0xa9,0x99,
  0x9f,0x98,0xf7,0x4b,0x3c,0xcd,0x7c,0xf5,0xa4,0x4f,0x5a,0x37,0xb1,0x2c,0x3f,0x19,
  0xdf,0xff,0xa5,0x26,0xde,0xc2,0x63,0x5b,0xe9,0x58,0xb5,0xa4,0xa1,0x66,0x3b,0xaf,
  0x9e,0x7e,0xeb,0xb8,0x19,0xcd,0xee,0xe4,0x78,0x78,0xa4,0x5a,0x7f,0x82,0x49,0xb9,
  0xc9,0xd4,0xfe,0xad,0x75,0xf1,0x8b,0x74,0x79,0xfe,0x2d,0x0c,0x71,0x53,0x12,0xd7,
  0xe6,0x9a,0xc7,0xe2,0x41,0x73,0x39,0x68,0xc7,0x47,0x25,0x1a,0x21,0x75,0x1e,0xc6,
  0xc6,0xd7,0x40,0x16,0x5f,0xd9,0x33,0x4b,0x8b,0xbe,0x5c,0x48,0xc9,0x7f,0xb8,0x5d,
  0x29,0x47,0x5e,0xa4,0x7f,0xc9,0x2f,0x69,0x6c,0xbe,0x18,0xcf,0x7f,0x58,0x23,0xc1,
  0x99,0x7f,0x15,0x6f,0x96,0xfb,0x67,0xbd,0xe5,0xf4,0x5e,0x73,0x7e,0x83,0xe9,0x0b,
  0xa7,0xf6,0xe2,0xa8,0xa4,0xe0,0x5b,0xb0,0xf4,0x42,0xea,0x68,0xd0,0x1e,0x46,0xa4,
  0xd6,0xbe,0x38,0x41,0xf3,0x1f,0x57,0xed,0x33,0x89,0x5d,0xf2,0x88,0xf3,0x35,0x58,
  0x13,0xb4,0xf7,0x9e,0xed,0x6f,0x94,0xd9,0xc2,0x56,0x4a,0x29,0xe1,0x5a,0x0c,0xb5,
  0xa9,0x39,0xdc,0xe7,0xf9,0x1c,0xac,0x57,0x02,0xb7,0xe3,0x9f,0xac,0xe5,0x4b,0xbc,
  0x8e,0xb2,0x94,0x3e,0x6e,0x0f,0x86,0x19,0x9f,0xf3,0x51,0x29,0x49,0xe9,0x9b,0x5e,
  0x5f,0x78,0xfc,0x62,0xda,0x5f,0xb4,0x4f,0x24,0x4c,0xad,0xc3,0xdc,0xe0,0x58,0xe2,
  0x43,0xc3,0xd7,0xf8,0x79,0xc5,0xfd,0xfd,0x90,0xa3,0x87,0x20,0x9f,0x47,0x73,0xe8,
  0x91,0x80,0xde,0x86,0x36,0xf9,0xac,0xf3,0x39,0xbd,0x88,0xea,0xbd,0xd3,0x53,0x1f,
  0xc1,0x4f,0xaf,0x2f,0x2e,0x36,0x90,0x3a,0x3e,0xa1,0xdc,0xd2,0x60,0x83,0xd1,0xb4,
  0x94,0xe7,0x26,0xc6,0x60,0x6a,0xcc,0x61,0x75,0xbf,0x80,0xd9,0x30,0xb0,0xe1,0x78,
  0xfe,0xc8,0x49,0xfb,0xb4,0x79,0x7d,0x31,0x1c,0x6c,0xcb,0xe4,0x15,0x32,0x64,0xdc,
  0x04,0x5e,0x9e,0x10,0xe2,0x4f,0xc2,0xf5,0xb3,0x86,0x50,0x4d,0xc5,0x4d,0xc4,0x12,
  0xae,0xdc,0x3e,0xda,0x20,0x75,0x25,0x9a,0x8c,0xf4,0x63,0x2e,0x25,0x55,0x4a,0x95,
  0x3a,0xbb,0x91,0xc1,0x2a,0x93,0x47,0x67,0x58,0xd2,0x8b,0x0c,0x57,0xea,0x12,0x6f,
  0x44,0xfb,0x2e,0xf2,0x93,0xea,0x3c,0xa9,0xa3,0x5f,0xaf,0xdb,0xfd,0x0f,0x9d,0xee,
  0x59,0x3e,0x9f,0x67,0xf3,0x8e,0x49,0x15,0x1a,0x9c,0xc0,0x24,0x4c,0x4b,0x9d,0xbd,
  0x3e,0x23,0xd9,0x5d,0xd6,0x67,0xfd,0xc0,0x40,0x54,0x22,0xf1,0xf3,0x74,0x1d,0xd7,
  0xcf,0x3e,0xa6,0xda,0xfa,0x5b,0x8b,0xfe,0xe2,0xd6,0x9b,0x7e,0x6c,0xd1,0xad,0x45,
  0xa3,0x2f,0xc9,0x6f,0xf4,0x91,0x52,0x48,0xae,0xee,0x1f,0x0c,0x7b,0xfd,0xe6,0x59,
  0x38,0x8f,0x39,0xe2,0xa6,0x86,0xa5,0x3e,0xfa,0xb6,0xc3,0x14,0x76,0xc4,0x7c,0x70,
  0x82,0x9b,0x81,0x2c,0xea,0xa4,0x4f,0x1f,0x1d,0x0b,0xe9,0x56,0xa1,0x62,0x8d,0xc1,
  0x3a,0xe7,0xfc,0x66,0x4c,0x64,0xdd,0x24,0xef,0xb6,0xcf,0xe0,0x43,0xb7,0xb5,0xfd,
  0xc6,0x06,0xe5,0x2d,0xc2,0x0a,0xaf,0x66,0xae,0xc0,0x7e,0x23,0x49,0x42,0x62,0xc6,
  0x3c,0x6b,0x19,0xcc,0xab,0xc7,0x8b,0xcb,0x58,0x48,0x81,0x24,0xd5,0xbf,0xf2,0x22,
  0x3f,0xab,0x15,0xf9,0x83,0xaf,0xf2,0xd3,0x4a,0x0b,0xc1,0xcb,0xfc,0xfc,0x16,0x7f,
  0xc0,0x72,0x70,0x05,0x59,0x28,0xe5,0x36,0x7a,0xa3,0x05,0xaf,0xdd,0xb3,0xab,0x73,
  0x27,0xfe,0x02,0x1a,0x6f,0x16,0xf8,0x4b,0x89,0x75,0xe9,0xb2,0x7d,0xd2,0x69,0x4a,
  0xcd,0x7e,0xeb,0xdc,0x7f,0xed,0x5a,0x84,0xea,0x95,0xc7,0x4c,0x25,0xcc,0x62,0xc4,
  0x85,0x6e,0x93,0x49,0x7a,0xf7,0x88,0xf8,0x9d,0xb1,0x53,0x10,0xc0,0xa1,0x0b,0x7c,
  0x5b,0x04,0xff,0x44,0x03,0xde,0xd4,0x9a,0x86,0x71,0xaa,0x1b,0x9a,0xcd,0xae,0x30,
  0x1e,0x96,0x95,0xba,0x74,0x75,0xdd,0x3f,0x6b,0x4b,0xcd,0x8b,0xd0,0x9d,0x37,0x9f,
  0xf2,0xe5,0x95,0x38,0x79,0x21,0x8c,0x16,0xf9,0x72,0x94,0xa0,0x64,0x08,0xab,0xab,
  0x29,0x56,0xd0,0x38,0x13,0xef,0x72,0x46,0xb2,0xf7,0xa0,0xd5,0xec,0x76,0x81,0xbd,
  0x39,0x5d,0x5d,0x36,0x8f,0x1b,0xc9,0x5f,0x5e,0x8f,0x0e,0x88,0xcf,0x2e,0xe1,0x11,
  0xa9,0x80,0x10,0x79,0x59,0x3f,0x86,0x80,0x01,0x69,0xc1,0x61,0xb1,0x75,0x61,0x6b,
  0x52,0x80,0x35,0xb9,0xe8,0x35,0x4f,0xa4,0xcb,0x5e,0xf0,0xd2,0xa6,0x57,0xae,0x44,
  0xdc,0x67,0xfc,0x2f,0x81,0xa3,0xb1,0x92,0x5f,0xca,0x73,0x6c,0x58,0x5d,0x3f,0x4f,
  0xdf,0xbd,0xb5,0xc7,0x96,0xbe,0x72,0x8e,0x76,0x60,0x11,0x25,0xed,0xae,0x37,0x9d,
  0x82,0x1a,0x6f,0x28,0xf5,0x1d,0x10,0xed,0xb6,0x03,0x7b,0xec,0xf3,0x15,0xc8,0xbf,
  0x46,0x11,0x9e,0xd0,0x16,0x43,0xd3,0x51,0x8d,0x06,0xfb,0xfa,0x79,0x65,0x69,0x77,
  0xe4,0x52,0x28,0x59,0xb5,0x46,0xae,0xc0,0x9e,0xd3,0x5b,0x61,0xe4,0xae,0x3e,0x7d,
  0x03,0x1d,0x76,0xa6,0xb7,0x4b,0x5a,0x19,0x83,0x97,0x35,0xc1,0x6c,0xed,0x2c,0x90,
  0x83,0xfc,0x48,0xb4,0x6b,0x0b,0xfd,0xf3,0x56,0xb3,0x1e,0x07,0x24,0xa0,0x69,0x5a,
  0xc0,0x57,0x69,0x19,0x7f,0x9c,0x1b,0xac,0xa1,0xa9,0x69,0xb5,0xd5,0xf1,0x3c,0xed,
  0x34,0x8e,0x9c,0x3c,0x99,0xd2,0x85,0x6e,0x3b,0x79,0x90,0x9b,0xe6,0x9d,0x96,0x96,
  0x69,0xbd,0x0d,0x39,0x43,0x6a,0xb2,0xc5,0x41,0x63,0x7b,0x5a,0x80,0x68,0x37,0x8e,
  0xec,0xc4,0x10,0x83,0xb6,0x1a,0x4a,0x0d,0x79,0x17,0xe7,0x92,0x11,0x60,0x80,0x84,
  0xf0,0x00,0x90,0xda,0x82,0xce,0x32,0xee,0xb5,0x3e,0x25,0xe4,0x68,0x34,0x1a,0xbc,
  0xd8,0x4b,0x66,0x1d,0xdc,0xaa,0xf5,0x28,0xba,0xd2,0x85,0x1a,0x35,0x36,0xe2,0xc7,
  0x8b,0xc2,0xc0,0x38,0x30,0xc8,0x28,0xb3,0x1e,0xe5,0x09,0xb7,0xe6,0x19,0xb3,0x36,
  0x64,0xe4,0x56,0xb9,0x3e,0xf2,0x99,0x9b,0xb2,0x5c,0x7f,0x7a,0xf2,0xe3,0x45,0x6a,
  0xdc,0x50,0xac,0xa8,0x59,0x94,0xce,0xd4,0xf1,0x0b,0xb5,0xfa,0x78,0x2e,0x32,0x3c,
  0x24,0x3f,0xb3,0xed,0xae,0x36,0xe1,0xba,0xf4,0xc2,0x9e,0x65,0x89,0x27,0x48,0x16,
  0x9b,0x7c,0x6a,0x90,0x3f,0xbf,0x7f,0x97,0x59,0x99,0x23,0x99,0x16,0xd3,0xc3,0xe9,
  0x68,0xc6,0xe6,0xf9,0x10,0x78,0x94,0x68,0x9a,0xe1,0xc3,0x19,0xc6,0x60,0x4f,0xe9,
  0x04,0xa9,0xea,0x6f,0x79,0x63,0xf9,0xde,0x8e,0x37,0x3c,0x77,0xc9,0x42,0x4c,0x01,
  0x8a,0x94,0xa1,0xa9,0x16,0x5e,0xb1,0x31,0x6f,0x9d,0x34,0x34,0xfc,0xec,0xf0,0xe1,
  0x3f,0x3b,0x0d,0x76,0xfb,0x06,0x5f,0xa5,0x33,0x8d,0xa3,0x30,0x1c,0x42,0xde,0x6c,
  0x69,0x5f,0x51,0xa0,0x17,0x50,0x86,0x4e,0x11,0x44,0xed,0xe7,0x93,0xce,0xe5,0xa0,
  0xb1,0x2e,0xd4,0x3e,0x15,0x2a,0x4a,0xb6,0x50,0x54,0xfe,0xc8,0xee,0xd7,0x3e,0x95,
  0x8a,0x4a,0xb6,0x58,0x86,0xcf,0x95,0xda,0xa7,0xb2,0x02,0x9f,0x0f,0x2b,0x7f,0x64,
  0x0f,0xe0,0x73,0x55,0xc9,0x96,0xb0,0x0d,0x8c,0x5c,0xad,0x7d,0xaa,0x94,0x95,0x2c,
  0x3c,0xfa,0x23,0x7b,0x58,0xfb,0x54,0x85,0x66,0x15,0x05,0x3e,0x17,0x14,0x80,0xa5,
  0x14,0xcb,0xd9,0x83,0x4a,0x15,0xbe,0x15,0xe1,0x5b,0x11,0xba,0xe1,0x23,0xf8,0x5a,
  0x22,0x03,0x91,0x91,0x94,0x3f,0x9e,0xc4,0x1d,0x89,0x33,0x45,0x41,0x36,0x34,0x4f,
  0xb1,0x36,0x65,0x5a,0x5f,0xcc,0xd8,0x3a,0x21,0xaa,0xf7,0x0d,0xf8,0x9e,0x5f,0x92,
  0xc4,0x48,0xe3,0x06,0xad,0xaf,0xec,0x5c,0x7c,0x74,0x4e,0xcc,0x30,0xc6,0xc5,0xf7,
  0x47,0xca,0x9b,0x37,0xf3,0x23,0x85,0xf4,0xe7,0x10,0xcc,0xe9,0x74,0xf3,0x82,0xba,
  0x85,0x61,0xe8,0xa2,0x4a,0xd8,0x9a,0xd1,0x90,0x16,0xbc,0xba,0xdf,0x95,0x57,0x0f,
  0x72,0xdd,0x7b,0xcc,0xea,0x80,0xcd,0xe9,0x73,0xe8,0xe3,0xe7,0x38,0xdf,0x1d,0x7d,
  0x44,0x83,0xb2,0xa0,0xcc,0x6a,0xb1,0xa0,0xf4,0xc7,0x3b,0xd9,0x20,0xfa,0xe5,0xac,
  0xcb,0x7c,0x19,0x8f,0xfb,0xc0,0x4c,0x6b,0xac,0x54,0xcb,0xd6,0xc0,0x5f,0x4c,0x6f,
  0x41,0xbb,0xaf,0xc1,0x4e,0x65,0x4e,0x97,0x07,0x61,0xba,0xb2,0xb7,0xcd,0xf7,0x74,
  0xe5,0x76,0x24,0x05,0x4d,0xf1,0xc7,0xee,0xd3,0xf2,0x9e,0xba,0xd2,0xf7,0x68,0x83,
  0x3d,0x32,0x8d,0x77,0x88,0x8c,0xbc,0x0b,0x7f,0xee,0xca,0x6f,0x10,0xac,0xbc,0x0b,
  0x7f,0x66,0x08,0x9d,0xf2,0xce,0x5c,0x5b,0x12,0xa6,0x5b,0x33,0x55,0x43,0x47,0x87,
  0xa5,0xd9,0x36,0x7a,0x67,0x31,0xe3,0xd4,0xe6,0xbd,0x26,0xfa,0xc2,0x6e,0x70,0xae,
  0xfc,0x04,0x03,0xfe,0xf1,0xfd,0xbb,0xcb,0x65,0xbc,0x29,0xae,0x3a,0x5d,0x14,0x6c,
  0xfe,0x09,0x5e,0xe0,0x13,0xb6,0x1e,0xe4,0x51,0xc1,0xd7,0xd6,0x5c,0xa2,0x84,0x68,
  0xf0,0xa5,0x49,0xa3,0xf8,0xf0,0xb3,0x1a,0x29,0x69,0x55,0x7f,0x12,0x3b,0xd9,0xd6,
  0xb8,0x21,0xb3,0x72,0x7c,0xf2,0x2e,0x74,0x20,0x29,0x18,0xf9,0xb9,0x69,0x3b,0x28,
  0x8b,0x76,0xe5,0x5a,0xb5,0xc0,0x88,0xf4,0x4e,0xde,0x3d,0x51,0x1d,0x2d,0xbf,0xc4,
  0x2b,0xf9,0x3e,0x18,0x9b,0xf6,0x32,0xfe,0x93,0x84,0x15,0xa3,0x85,0x64,0x32,0x00,
  0x6e,0xe9,0x9c,0x30,0x18,0x3f,0x22,0x8c,0x31,0x49,0x85,0x00,0x7a,0x65,0x92,0x72,
  0x24,0x16,0xd2,0xe3,0xeb,0xf3,0x04,0x6a,0x05,0xab,0xb2,0x91,0x85,0x16,0x3b,0xb4,
  0xfb,0xfd,0x5e,0x1f,0xdb,0x4f,0xa7,0x05,0xb5,0x48,0xf5,0x94,0x7f,0x1b,0x78,0x85,
  0x25,0xd6,0x9b,0x58,0xcc,0x24,0xf9,0xb9,0x7e,0x3e,0x7a,0x09,0x17,0x09,0x8b,0xbd,
  0xc4,0xba,0x6f,0xee,0x3a,0xca,0xf5,0x88,0xe5,0x10,0x88,0xf9,0x92,0xb5,0x40,0x0f,
  0x2e,0x59,0xf7,0x98,0x95,0x10,0x70,0x10,0xa9,0x8a,0x85,0x37,0xda,0x27,0x94,0xac,
  0x87,0x20,0xb3,0xe9,0x04,0x9f,0x02,0xb4,0x0d,0xd7,0x83,0x58,0xfb,0xc4,0x47,0x72,
  0xa9,0xf1,0xbf,0x27,0x34,0xee,0x09,0xe6,0xe4,0x37,0x07,0xd2,0x09,0xb7,0x1b,0x90,
  0xe5,0xf3,0xc8,0x50,0x97,0x5f,0x81,0xd9,0x28,0x34,0x8f,0x35,0x5f,0x09,0xce,0x4f,
  0xdf,0xc8,0xaa,0x38,0xeb,0xff,0x55,0x09,0xfd,0xfc,0x5d,0xc1,0x7a,0xd8,0x74,0x1a,
  0x60,0x1c,0x35,0x42,0x5b,0xe1,0xa7,0x86,0xc0,0x88,0x5c,0x4d,0x5d,0x5d,0x5d,0xa0,
  0x07,0x8e,0x26,0x42,0xef,0xe2,0x1a,0x4f,0xe2,0x23,0x54,0x55,0xc4,0xda,0xb3,0xf0,
  0xeb,0xf3,0x54,0x06,0xa8,0x6c,0x01,0xc3,0xcc,0xda,0x0d,0x72,0x44,0x69,0x05,0x97,
  0xe6,0x00,0x3c,0x13,0xa5,0x1f,0x9e,0xa7,0x21,0x24,0x29,0x60,0x3c,0xad,0x5f,0x25,
  0xfe,0x19,0xfd,0x3c,0xb2,0x49,0x48,0xca,0x0e,0xdd,0xcd,0xae,0x50,0x7d,0xca,0x1e,
  0x10,0x4b,0x8c,0x22,0xf0,0xa4,0x19,0xb6,0xb6,0x0e,0xf7,0xc4,0x3b,0x7a,0x81,0x7e,
  0x1b,0xa5,0x31,0xff,0x01,0xf5,0xd6,0x79,0xb3,0x0b,0x1e,0xef,0x69,0xb3,0x73,0xc1,
  0x25,0x48,0xa4,0x60,0x16,0x2a,0xf4,0x80,0x43,0x30,0x17,0x4c,0x14,0xf2,0xfd,0x9d,
  0x4c,0x0a,0xe9,0xb8,0x85,0x75,0x3a,0xdd,0xce,0xb0,0xd3,0x1c,0x52,0x83,0xa5,0x26,
  0x47,0x3e,0x8e,0x61,0x8e,0x15,0x8e,0xf4,0x8e,0x40,0x06,0x4e,0xe0,0x43,0x14,0x00,
  0x92,0xe2,0xee,0x62,0xc2,0x15,0x56,0xe3,0xc8,0xca,0x7f,0xb1,0x51,0x4b,0x33,0x95,
  0x30,0xf1,0xd8,0x84,0xe2,0x37,0xc9,0x9b,0x5f,0xdf,0xc9,0x57,0xe7,0xbd,0x61,0x8f,
  0x52,0x08,0x4b,0xdc,0x0d,0x4e,0x00,0x16,0x51,0x46,0x35,0x49,0xde,0x9d,0xe4,0x35,
  0x3c,0x56,0xce,0xd2,0xa6,0x9c,0x7c,0x35,0x8f,0x18,0x9b,0xb5,0x1a,0x9f,0xd9,0x56,
  0x02,0x8a,0xe5,0x70,0xd6,0xd4,0xec,0xfc,0x69,0x8c,0x45,0x24,0xac,0x05,0x2e,0xa2,
  0x50,0xfa,0x46,0xea,0xf6,0x6e,0xde,0x41,0x7f,0x4b,0x03,0x4b,0x75,0x29,0x6c,0x32,
  0xf6,0x9a,0x36,0xa6,0xe1,0xae,0xa0,0xcc,0x17,0x89,0xc8,0x46,0x94,0x45,0xac,0xd7,
  0x41,0xa5,0xe0,0x15,0x55,0x51,0xad,0x45,0x48,0xe5,0x52,0xdf,0xed,0x1d,0xbc,0xd2,
  0x26,0xb8,0x10,0xf0,0x61,0xeb,0x32,0x08,0x8f,0x61,0x2d,0x6e,0x57,0x13,0x60,0x76,
  0x3a,0xc4,0x75,0x07,0x16,0x83,0xc0,0xa2,0xc4,0x71,0x91,0x08,0x34,0xa2,0x4d,0x3c,
  0xc9,0x39,0x31,0x9d,0xcd,0xf2,0xcb,0x2d,0x8c,0x23,0xca,0x2f,0x72,0x00,0xb2,0xad,
  0x0f,0x29,0x8b,0xe3,0x7a,0xb2,0xde,0xa0,0xa8,0xa0,0x9d,0xa0,0xdf,0x8b,0xbe,0x77,
  0x9d,0xfe,0xb2,0xe8,0xe6,0x37,0x3e,0x67,0x94,0xd4,0xda,0xf1,0x2b,0xeb,0x60,0x81,
  0x20,0x89,0xb6,0x09,0x98,0x4f,0x74,0x7b,0x47,0x20,0xc2,0x7d,0xfc,0x48,0x5c,0x22,
  0x5e,0xfa,0xd0,0xe1,0xd5,0x7f,0xb6,0x60,0xe4,0x36,0x0b,0x1a,0x13,0x01,0x66,0xf6,
  0xca,0x55,0xd9,0xda,0xd8,0x16,0x3d,0x96,0x7e,0xbb,0xd5,0xeb,0x9f,0xa0,0x2e,0x90,
  0x77,0xf1,0xdd,0xae,0x6c,0x47,0x30,0xea,0xc6,0xb5,0xe1,0xf5,0x12,0xe3,0xcc,0x50,
  0x3f,0x97,0x23,0x2a,0xef,0x70,0xa4,0x06,0x1d,0x30,0xb1,0x7c,0x78,0x01,0x0e,0x3e,
  0x8b,0x5a,0x94,0x2f,0xcd,0xf7,0x1d,0x3c,0x04,0x22,0xf5,0x33,0x87,0xed,0x8b,0xf6,
  0x59,0xbf,0x79,0xf9,0x5a,0x11,0xb3,0x7e,0x31,0x82,0xbe,0xa5,0x88,0x90,0x4d,0xf5,
  0xa0,0x18,0x10,0x03,0x24,0x61,0xbb,0x1b,0x9f,0x73,0x93,0x3b,0x86,0xa2,0xcc,0xf3,
  0x3e,0x89,0xdb,0xae,0xac,0x0c,0xb2,0x6b,0x82,0x83,0xf3,0x0d,0x5f,0x33,0xf8,0x07,
  0x65,0xe6,0x2e,0x46,0x6e,0x64,0x5e,0x3b,0x19,0x64,0xce,0x24,0x8f,0x5f,0xde,0xc9,
  0x40,0x2c,0xf4,0xb2,0x79,0xcf,0xe7,0x8b,0x86,0x97,0x0a,0x07,0x82,0x25,0x17,0x5c,
  0xeb,0x1f,0x29,0x1b,0xa8,0x7a,0x26,0xdb,0xfd,0x3f,0xb2,0xd3,0x9f,0x38,0xf6,0x81,
  0xa0,0xe7,0x51,0x43,0x79,0xf3,0x86,0xcd,0x08,0x3f,0x10,0x75,0x6b,0x1f,0x05,0x5a,
  0xb9,0x76,0x55,0x28,0x84,0xb7,0xdb,0x48,0xf3,0x4e,0xb9,0x60,0x27,0xbf,0x83,0x9e,
  0x2c,0xc6,0xe7,0x99,0x75,0x24,0xd4,0x27,0xce,0x26,0x34,0x76,0x3d,0x14,0x0a,0x14,
  0x4f,0xc1,0xf8,0x9c,0xe9,0x9f,0xc1,0x58,0x2f,0x47,0x5a,0xe4,0x86,0xfb,0xe3,0x06,
  0xe3,0x30,0x52,0xb4,0x35,0x2d,0xf7,0xba,0x58,0x82,0x17,0x76,0x0b,0x58,0xc4,0x35,
  0xfe,0x8c,0xd6,0xe5,0x85,0x87,0x96,0x9f,0x97,0x16,0xd8,0x9b,0xd0,0x91,0x77,0xe7,
  0xd2,0x53,0xe8,0x2d,0xc8,0xd4,0x40,0x77,0x0b,0xbb,0x53,0x09,0x06,0x86,0xac,0x0b,
  0x82,0x7b,0xd5,0x96,0x07,0xa3,0x73,0x72,0x81,0x4f,0x1e,0xfd,0xfd,0xef,0x6f,0x09,
  0xf6,0x04,0x81,0xeb,0x15,0xef,0xdf,0x6f,0x37,0x4f,0x3e,0xf8,0x51,0xb8,0x01,0x04,
  0x72,0xd7,0x57,0x22,0x84,0x18,0x8f,0x80,0x9f,0xe5,0xc2,0x9e,0xd7,0x97,0x4b,0xcd,
  0x3a,0x1f,0x5e,0x5e,0x34,0xd8,0x22,0x59,0x60,0xb6,0xca,0xd7,0x57,0x58,0xd9,0x49,
  0x06,0x69,0x76,0xbb,0xc2,0xba,0x47,0x99,0x5d,0xf1,0x2d,0xab,0xa6,0x2e,0x67,0xef,
  0x8f,0xfd,0x2f,0x3a,0x57,0x52,0xf3,0xe4,0xa4,0x8f,0xfd,0xf4,0x95,0xff,0xd5,0xa0,
  0x73,0xd6,0x6d,0x5e,0xe0,0x1b,0xcb,0xb6,0xf5,0x5d,0x59,0x9a,0x1c,0x2f,0x64,0x7f,
  0x93,0xcb,0xd6,0x35,0x88,0xd6,0xcb,0x2b,0x6c,0x84,0xbf,0x42,0x06,0x8d,0xde,0xfc,
  0x5c,0x2d,0xef,0x17,0xea,0x81,0x86,0x83,0x21,0x50,0xe0,0x92,0xc0,0xd2,0xc8,0x4f,
  0x72,0x02,0x03,0xf9,0x5b,0x10,0x6b,0x70,0x80,0x2d,0x28,0x43,0xf8,0xdf,0xe2,0x8f,
  0x8f,0xd0,0xb7,0x58,0xf2,0x24,0xf8,0x96,0xaa,0x4c,0x39,0xbb,0x08,0x4c,0xee,0xf2,
  0x84,0x9c,0x90,0x03,0x55,0x60,0x55,0x02,0x08,0xb5,0xbb,0x03,0x30,0x7c,0xdf,0x83,
  0xc1,0x8d,0x50,0x85,0x62,0x6f,0xfe,0x76,0xad,0x5e,0xef,0xe2,0xa4,0x77,0xd3,0xc5,
  0x46,0xbc,0xa0,0x19,0xa8,0xcf,0xc0,0xf4,0x5c,0x05,0x2b,0x67,0xad,0xc0,0x40,0xa7,
  0xfd,0x76,0x5b,0x3a,0x6f,0x37,0x09,0x8d,0xa6,0x96,0xa6,0x9d,0x6b,0x2a,0xd2,0xe9,
  0x97,0x63,0x39,0xa2,0xe1,0xd5,0xa0,0x4f,0xc9,0x84,0x2d,0xaf,0x6c,0x4b,0x5d,0xb0,
  0xa6,0xdb,0x18,0x24,0x58,0xac,0x8e,0xbb,0x9c,0x0d,0xdf,0xdc,0x12,0x40,0x09,0x97,
  0xa5,0x7b,0x0e,0x04,0x5f,0xcd,0x37,0x01,0x07,0xfe,0x5c,0x10,0xde,0xbc,0x06,0x4f,
  0x26,0x56,0x31,0x61,0x0b,0x01,0x0e,0x7f,0x24,0x2a,0x01,0x52,0x70,0x68,0x33,0x14,
  0xaf,0x20,0x51,0x7c,0x18,0x8d,0x6e,0x5f,0x67,0xd6,0x8e,0x3b,0x34,0x60,0x65,0x65,
  0x04,0x2d,0x84,0x1d,0x32,0xf8,0x47,0x80,0x66,0xce,0x8c,0xd6,0xa3,0xbb,0xb5,0x40,
  0x10,0xc9,0x9f,0x7a,0xbf,0xfc,0xe1,0x1a,0x21,0xac,0xa6,0x09,0x1e,0xd9,0x82,0x06,
  0xfd,0x94,0xcb,0x09,0xaf,0xba,0xbd,0xa1,0xf8,0x5a,0x98,0xa7,0x1b,0x86,0x00,0x67,
  0xff,0x76,0x39,0xd1,0xa6,0x20,0x61,0x27,0x19,0x7f,0xc8,0xd6,0x8e,0xd3,0xa2,0x42,
  0x1c,0x83,0x8b,0x77,0x68,0xef,0xb1,0x09,0x7f,0x8d,0xe7,0x3b,0xf8,0x82,0x97,0xfc,
  0xed,0xe0,0x8f,0x5d,0xbd,0x55,0x32,0x5e,0x63,0xb9,0xca,0x10,0x7b,0x0a,0xa2,0x77,
  0xba,0xf2,0xa3,0x97,0x3c,0x36,0xd2,0x10,0x40,0x08,0xb3,0x76,0x4b,0xb8,0xf9,0xc0,
  0x52,0xef,0x64,0x68,0x10,0xf7,0xc5,0x6d,0x82,0x42,0xc8,0xad,0x7b,0xf6,0xfd,0x7b,
  0x49,0x61,0x31,0xb7,0x38,0x67,0x4b,0xc8,0xb0,0x40,0x52,0xde,0xa9,0x16,0x1e,0xb1,
  0xc5,0x10,0x51,0x48,0xc0,0x70,0x1d,0x15,0x72,0xf8,0x88,0x27,0x73,0x3e,0xa5,0x8f,
  0x26,0x76,0x1d,0x9f,0xb2,0x72,0x74,0x93,0x06,0x1e,0xbf,0x11,0x6d,0xe8,0xb3,0xe5,
  0x26,0x28,0xdd,0x93,0x18,0x73,0x31,0xc4,0x74,0xd3,0x31,0x36,0xea,0x87,0x56,0x13,
  0xcc,0xce,0xe1,0x87,0x2b,0xa2,0x22,0xec,0xc9,0xf0,0x71,0x15,0x50,0x11,0xe0,0x36,
  0x37,0x5b,0x5c,0x1c,0x4e,0xc8,0x01,0x2d,0xc8,0x9e,0xcb,0xa0,0x98,0xba,0x1e,0xa0,
  0xd6,0xc4,0x26,0xd7,0xb6,0x36,0x89,0x6a,0x81,0x82,0x8c,0xb6,0x38,0x05,0x21,0xc6,
  0x5a,0xb8,0x4b,0x1a,0x4d,0x2b,0x31,0x05,0x25,0x40,0x34,0x52,0x59,0x94,0x50,0xcd,
  0xbf,0x92,0xaf,0x80,0x15,0x62,0x02,0x40,0x9b,0x58,0x6d,0x59,0x60,0x1c,0xc2,0x07,
  0xd4,0xd1,0x97,0x64,0x5f,0xd6,0x9b,0xc5,0xd3,0xdd,0xe4,0x5d,0xd2,0x7a,0x57,0xf6,
  0x25,0xbd,0xc9,0xbb,0x77,0xaa,0xf0,0x8c,0x1c,0x8d,0xcb,0x3e,0xa7,0x9a,0x6a,0x7e,
  0x44,0x36,0x8b,0x99,0x7f,0xfe,0x91,0xc4,0x6c,0x06,0xd2,0x90,0x36,0xcf,0xc9,0xbb,
  0xd8,0x76,0x57,0x4e,0xc1,0x00,0xd8,0xd5,0x1d,0x41,0x0e,0xfb,0x0b,0xec,0x98,0x97,
  0x64,0xd1,0xf1,0x90,0x86,0xf7,0x45,0xf2,0x1d,0xcd,0xc7,0x72,0x94,0x97,0x07,0xe1,
  0x63,0x28,0xf9,0x79,0xc9,0x10,0xec,0x50,0xcd,0xcf,0xef,0x14,0xf4,0x3b,0x93,0x22,
  0x22,0xef,0x72,0x9c,0x76,0xe5,0x37,0x86,0xbe,0xd0,0xf1,0x11,0xcb,0x17,0xd8,0xe2,
  0x35,0xaa,0x8e,0xea,0x39,0x8e,0x3c,0xa5,0x00,0x9f,0xe6,0x1d,0xfc,0xf8,0xfd,0xbb,
  0xe2,0x37,0x7c,0xa7,0x98,0x59,0x42,0x1b,0x90,0x8f,0xdf,0xbf,0x7f,0xfa,0xc3,0xdf,
  0x02,0xf3,0x40,0x1a,0x89,0x68,0x22,0xd8,0xc7,0x2e,0x4d,0x1b,0x0d,0x45,0x88,0x7b,
  0x62,0x30,0x89,0x0c,0x93,0x37,0xb4,0xe5,0xcc,0x99,0x0b,0xaf,0x24,0x32,0xd0,0x56,
  0xb2,0x76,0x7b,0x2c,0x77,0xa7,0xd7,0x95,0xa8,0x81,0x21,0x50,0x95,0xff,0x13,0x83,
  0x2d,0x31,0xb0,0x03,0xba,0x5c,0x4e,0xd6,0x59,0xcc,0x4a,0xd9,0xe2,0x71,0x93,0x6d,
  0xef,0x86,0xc5,0x58,0x34,0x74,0x67,0xd3,0x44,0xdd,0x6e,0xbc,0x09,0x25,0x11,0xcf,
  0xa0,0x98,0x7a,0x0b,0xea,0xc6,0xbd,0x27,0x0d,0x79,0x2c,0xef,0x5e,0xaa,0xce,0x3c,
  0x6f,0xa9,0xcb,0x89,0xb9,0x48,0xc3,0x94,0xcc,0x81,0x63,0x01,0x91,0xd2,0xa5,0x0a,
  0x60,0x77,0x3b,0x02,0xcd,0x91,0x2e,0x66,0x0f,0x33,0xf5,0x40,0xe7,0x2f,0xab,0x59,
  0x63,0x9a,0xc7,0x70,0x6f,0x5e,0x5b,0x4e,0xec,0x1b,0xdd,0x01,0x2e,0xcc,0xc3,0x53,
  0x39,0xf3,0xfd,0x7b,0xd4,0x0b,0x4d,0x38,0xcf,0xe4,0x40,0x30,0xe5,0xca,0xe3,0x8a,
  0x31,0xe8,0x28,0x47,0x63,0xd4,0x4a,0xcb,0xb0,0x20,0xbe,0x1e,0xd0,0x56,0x74,0x9a,
  0xd9,0x0f,0xd3,0xca,0x75,0xf2,0x02,0xe6,0xa2,0x4f,0x02,0x8d,0x43,0xd2,0x1a,0xff,
  0x49,0x03,0x8a,0xbe,0x24,0xfa,0x77,0x32,0xf9,0x6d,0x0f,0x8c,0x69,0xa7,0xc8,0x2e,
  0x72,0xe6,0xb7,0x8b,0xd1,0xbb,0x29,0xee,0x9f,0xe5,0x18,0xec,0x9b,0xeb,0x7e,0x07,
  0x2f,0x9a,0xc3,0xca,0x00,0x56,0xd3,0xfc,0x0a,0xc8,0x95,0x01,0x99,0x21,0x31,0x6e,
  0x02,0xb6,0x52,0xbf,0x91,0x5c,0x21,0x12,0xf3,0x68,0xa4,0x48,0x92,0xaf,0x7f,0x5d,
  0x7f,0x27,0x0b,0xfb,0xbb,0x5c,0x27,0xef,0x96,0xc0,0x35,0x6c,0x96,0x03,0x7d,0x84,
  0x17,0x25,0x43,0xcd,0x89,0xf5,0xf4,0x3b,0x0a,0x26,0x1f,0xae,0x92,0xb4,0x2b,0x07,
  0x12,0xac,0xf8,0xaf,0xe7,0x6e,0xc8,0x70,0x22,0x35,0xed,0xca,0xe5,0x32,0xfb,0x81,
  0x16,0x3f,0xb8,0xda,0x46,0x60,0xa4,0xdf,0xc1,0xa1,0x72,0xc8,0xfb,0x65,0x76,0x62,
  0x70,0xc0,0xdf,0xc1,0x05,0x01,0x3e,0xe2,0xb5,0x62,0xe5,0x5d,0xca,0x00,0x54,0xb2,
  0xf2,0xcf,0x6f,0xf7,0x46,0xe4,0x1b,0xa6,0x53,0xe2,0xb7,0x20,0x3e,0x21,0xb0,0xf8,
  0x8b,0xac,0xa9,0x60,0x13,0x55,0x9a,0x83,0x61,0xc1,0x96,0x0a,0xed,0x5e,0x5c,0x86,
  0x04,0xab,0xc5,0x9b,0xfa,0xb1,0x23,0x65,0xe0,0x41,0xa1,0x9d,0x5c,0xbc,0xdd,0x53,
  0x83,0x43,0xb1,0xac,0x30,0x31,0x91,0x0e,0x53,0xe8,0xd2,0xbf,0xcb,0x08,0x62,0x45,
  0xb6,0x8d,0x46,0x4a,0x26,0xa6,0xf7,0xe4,0xbd,0x59,0x36,0xf5,0x3b,0xac,0x18,0x0c,
  0xf6,0xbb,0x9c,0xc5,0x26,0xfa,0x04,0x3f,0x7a,0xe9,0x76,0x6e,0x82,0x58,0x60,0x98,
  0xa0,0xe4,0x21,0x1b,0x5b,0x5d,0xad,0x60,0xf7,0xb4,0xe6,0xba,0x31,0x49,0xbb,0xbf,
  0xd4,0x4a,0x63,0x66,0x75,0x57,0x2e,0x33,0xe9,0xde,0x10,0x85,0xe1,0xd6,0x03,0xf0,
  0x0d,0xd2,0x8b,0x8a,0xc1,0x01,0x46,0xef,0x3c,0xb5,0x21,0xed,0x91,0xaf,0x44,0xfe,
  0x6f,0x05,0x1c,0x2b,0xd9,0x5c,0x59,0xfe,0x96,0x81,0xcb,0xbc,0x63,0x2e,0x42,0x4d,
  0x14,0x7a,0x7e,0x3b,0x64,0xfb,0x54,0x9e,0xa9,0x4a,0x59,0x70,0xd0,0x47,0xf2,0xa8,
  0xe0,0xa0,0x98,0xea,0x27,0x26,0x79,0xd1,0x52,0xec,0x75,0xb1,0x39,0x67,0x0a,0x64,
  0x87,0xac,0x3e,0x09,0x9f,0x76,0x90,0x24,0x4b,0x24,0x2b,0x61,0x18,0xa0,0x86,0x0e,
  0xb2,0x6d,0x0f,0x10,0x5e,0x99,0xab,0x34,0x70,0x8b,0xff,0xf0,0x43,0x54,0xe7,0x34,
  0x71,0x73,0x13,0x6f,0x13,0xce,0xce,0xae,0x17,0x9a,0x33,0x37,0x27,0x35,0xf9,0x04,
  0xdc,0x1c,0x70,0xc7,0x9f,0x12,0xc7,0x83,0x89,0x0f,0x60,0x7e,0x0d,0x9d,0x27,0x8e,
  0x37,0xaa,0x69,0x98,0x1d,0x3a,0x30,0xe3,0xcc,0x98,0x47,0xe5,0x04,0xf1,0xec,0xea,
  0x6a,0xa2,0x4e,0xf0,0x27,0xd1,0x95,0x2c,0x7f,0x96,0x2b,0x64,0xea,0xdc,0x8a,0xf0,
  0xbd,0x26,0x8f,0xf0,0xed,0xce,0x4b,0x95,0x6e,0x62,0xb6,0xf5,0x72,0x08,0x80,0x03,
  0x68,0xe6,0xeb,0x89,0xec,0x3f,0x64,0xe4,0x2d,0x42,0x61,0xec,0x70,0xdc,0xda,0xcf,
  0x32,0xc1,0x0c,0xdb,0x68,0x1e,0xc0,0x44,0x5b,0x66,0x76,0x9c,0xf6,0x7b,0x97,0xd2,
  0xe0,0xe4,0x9d,0x34,0x3c,0xef,0x0c,0x24,0xb4,0xf1,0xc0,0x37,0x3d,0x6e,0x4b,0xd7,
  0xdd,0x93,0x5e,0xb7,0x9d,0x8f,0x3a,0x0e,0x43,0x10,0xc4,0x10,0x04,0x20,0x38,0x85,
  0xc1,0x96,0xf3,0x30,0x8a,0x93,0x6a,0x18,0xf2,0x8f,0xe0,0x11,0x7e,0xf0,0x4d,0xad,
  0x50,0xa9,0x75,0xd1,0x6e,0x62,0x56,0x74,0x1a,0x69,0x44,0x92,0x83,0x81,0xe8,0x44,
  0x0a,0x49,0x94,0x33,0x26,0x19,0xdf,0x39,0x4f,0x28,0x4f,0x92,0xdb,0x28,0xcf,0x24,
  0x7b,0xf8,0x44,0x92,0x52,0x76,0xeb,0x79,0x64,0xb8,0x94,0x7d,0x30,0xee,0x4f,0xd6,
  0x6a,0x06,0xc4,0x22,0x43,0x71,0x8a,0x5d,0xf5,0x06,0x43,0x39,0x4b,0x1e,0xd1,0xdf,
  0xcc,0xb0,0x6b,0x6b,0x99,0x31,0x5f,0x0e,0x1d,0x3d,0x10,0x5f,0x20,0xaa,0x41,0x3f,
  0x90,0x23,0xf0,0x3d,0x24,0xa4,0xfc,0x44,0x3b,0xe0,0xf5,0x96,0xda,0x3f,0x06,0xbd,
  0x2e,0x7a,0xdf,0x20,0x82,0xf4,0xe9,0x63,0x7a,0xed,0x46,0x07,0xdc,0xb0,0x4f,0x2d,
  0x41,0x9a,0xc4,0xa6,0x10,0x54,0x26,0xeb,0x1a,0xd9,0x34,0x08,0x94,0x00,0x58,0x64,
  0x1c,0x29,0xc3,0x08,0x4c,0x5d,0xc1,0xcd,0x8c,0xb1,0x13,0x3c,0x09,0xf2,0x95,0xf4,
  0x67,0x67,0xf2,0xcf,0x39,0x08,0x02,0x80,0x11,0x4b,0xe5,0x2b,0xe2,0xeb,0x1d,0x8d,
  0xda,0x76,0x9c,0x13,0x11,0x8c,0x69,0xe5,0x81,0xea,0x8b,0xb4,0x70,0x4e,0x8a,0xd5,
  0x97,0xe3,0xbb,0x63,0xd9,0xe8,0x70,0x46,0x89,0x83,0x85,0x99,0x37,0x77,0xe4,0xa5,
  0x9b,0x37,0x8e,0x3b,0x8e,0xc3,0x9a,0x96,0x5e,0xde,0xd8,0x17,0x99,0xa8,0xb1,0x7e,
  0x62,0xd1,0x10,0x24,0x00,0xb8,0xe5,0xf0,0xcc,0x0d,0xd7,0x35,0xf0,0x59,0xdd,0x7d,
  0x84,0x33,0x68,0xe0,0x44,0xeb,0x2c,0x37,0x98,0x20,0xcf,0xfa,0x70,0x4c,0x1b,0xe4,
  0x21,0x6f,0x31,0x76,0x61,0x52,0x5c,0x1a,0xf0,0x80,0xbf,0xeb,0x8d,0xbe,0x68,0x63,
  0x27,0xff,0x55,0x7b,0xb4,0xd3,0xd8,0x24,0xc3,0xac,0x0c,0xea,0x91,0xb1,0x3d,0x08,
  0xc2,0xeb,0x1c,0x45,0x13,0x4b,0x39,0xf0,0x49,0x25,0x26,0xc7,0x9e,0x84,0x73,0xfd,
  0xe6,0x7b,0x6c,0x4c,0x39,0x66,0x4b,0x66,0xc4,0x9f,0xb3,0x29,0xc9,0xc4,0xb6,0x71,
  0xfe,0x7a,0x47,0x10,0x88,0x78,0x8c,0x64,0x69,0x23,0xd3,0x74,0x32,0x3c,0x33,0x42,
  0xd8,0x00,0xf9,0x50,0xd2,0x82,0x3f,0x5f,0x50,0x10,0x7a,0x74,0x5f,0xbc,0x78,0xf7,
  0x84,0x82,0x70,0x1e,0x8d,0x93,0x08,0x45,0xdf,0xaf,0x12,0x78,0xdb,0x8c,0x66,0xbd,
  0xc7,0x84,0x6a,0xd9,0x4f,0x39,0x60,0xae,0x85,0x77,0x49,0x5b,0xc8,0xa7,0x62,0x71,
  0xc2,0x04,0x09,0x60,0x5e,0x50,0xd1,0x95,0x44,0x18,0x5d,0x0c,0xf2,0x81,0x1b,0x87,
  0x7c,0xc7,0x70,0x93,0x77,0xe9,0x87,0x5d,0xf9,0x8d,0x3b,0x1a,0x58,0xdc,0xec,0x63,
  0xb2,0x64,0x8d,0xb5,0x2f,0xd4,0x49,0xe1,0xe1,0x59,0x0d,0x07,0x52,0xe7,0x4b,0x44,
  0x5f,0xbd,0x93,0xdd,0xdf,0xf7,0x60,0x99,0xa0,0x54,0xfd,0xf1,0xf6,0xbb,0xb2,0x9d,
  0x81,0xb5,0xf1,0x1a,0x0d,0x86,0xbd,0xab,0x2b,0x62,0x64,0x3c,0x85,0x52,0xf1,0xd8,
  0x3a,0x79,0x8d,0xb7,0xa5,0x8a,0x0a,0xb8,0x32,0x4c,0x5d,0x3c,0x05,0xf9,0x48,0x22,
  0xe8,0x71,0x0b,0x27,0xc6,0xd8,0xb9,0x70,0xc3,0xa5,0x4c,0xb2,0xd8,0xe2,0x02,0x4f,
  0xcd,0xb8,0x1e,0xfc,0xf7,0x27,0xdc,0x28,0xee,0x4f,0x14,0x33,0x9f,0x55,0x83,0x40,
  0x39,0xff,0x34,0x7e,0xfa,0x89,0xce,0x8a,0xa7,0xa7,0x90,0x2f,0x99,0x35,0xed,0x16,
  0x38,0x4d,0xa6,0xb4,0xc7,0x1f,0x3c,0xf0,0x56,0x1c,0x88,0x4f,0xae,0x68,0xf5,0xdf,
  0x37,0x2f,0xe4,0x3a,0xeb,0x26,0xde,0x22,0x90,0xe9,0x95,0xc3,0x19,0x96,0x3d,0xcd,
  0xd0,0x73,0x53,0x72,0x12,0x1d,0x35,0x02,0xff,0x71,0x94,0x38,0x40,0xa4,0x7e,0xbd,
  0x8c,0xe6,0x30,0x12,0x23,0x83,0x7f,0x84,0x6e,0x67,0x78,0x57,0x09,0x5a,0xcd,0xcb,
  0xcf,0xef,0x9b,0xfd,0xcf,0x97,0xcd,0xab,0x06,0x2e,0x17,0x2b,0x0b,0x5e,0xf3,0x15,
  0xef,0x76,0xeb,0x55,0xd7,0x84,0x9a,0xd2,0x58,0x49,0xb9,0xe6,0x2b,0x79,0x4c,0xeb,
  0xfc,0xd6,0xc4,0x72,0xbc,0x08,0x91,0x96,0xb1,0xad,0x85,0x6b,0xd6,0x36,0x6f,0x8e,
  0x6b,0x58,0x5e,0x93,0x7e,0x3c,0xab,0x09,0xa5,0x36,0x59,0x61,0xcb,0x9a,0x57,0xc5,
  0x12,0x57,0xa6,0xd9,0x6e,0xd5,0xb0,0x12,0x1a,0x76,0x68,0xb7,0x8a,0x35,0x56,0xd1,
  0x0f,0x8b,0xde,0xd5,0x84,0xea,0x74,0xa4,0x0c,0x5b,0x4d,0x2c,0x99,0x46,0x3a,0x9f,
  0x61,0xe7,0xd9,0x18,0xdf,0x9f,0xb5,0xce,0x6a,0x42,0xa1,0x2b,0x1b,0x5f,0xf9,0xaa,
  0x43,0x61,0x87,0xe3,0x2b,0x78,0x4a,0xab,0xfd,0xdc,0xe0,0x47,0x5a,0xf1,0x06,0xeb,
  0xc2,0xd4,0x78,0xf1,0x17,0x2c,0x90,0x52,0xf3,0xaa,0xa1,0x60,0x2f,0x52,0x38,0xa4,
  0xe6,0x56,0x09,0x39,0x69,0xdd,0xd4,0x58,0xdd,0x0c,0x2c,0x2f,0x51,0xf3,0x6a,0x49,
  0xec,0xf8,0x6e,0x51,0xf0,0x7b,0xd9,0xa0,0xcf,0xb2,0xfe,0xad,0x03,0xab,0x4a,0xc2,
  0x4a,0xc2,0x4a,0x7d,0x82,0x56,0x7f,0x7c,0xff,0x0e,0x7f,0x8a,0xe2,0x68,0x4c,0x7f,
  0x06,0xf1,0x1d,0x74,0x68,0x60,0x58,0x9a,0x74,0x03,0x31,0x44,0x25,0x90,0x2b,0xf1,
  0x10,0xfa,0xb6,0x54,0x34,0x5a,0xed,0xc0,0xc3,0x01,0x8b,0x3f,0x24,0x90,0x99,0xd8,
  0x4c,0x90,0x96,0x45,0x9f,0xb4,0xc4,0x97,0xef,0x08,0x20,0x79,0x17,0xff,0x0a,0x88,
  0x42,0x0c,0xed,0x5b,0x68,0xd1,0x33,0x01,0x44,0x0a,0x5e,0x0c,0xda,0x43,0xd4,0x36,
  0xd8,0x1c,0x8f,0x14,0xce,0xbf,0xc1,0xbe,0x15,0x0d,0x73,0xd2,0x28,0x24,0xa0,0x36,
  0x4b,0xb5,0xe8,0xf6,0x11,0x6e,0x76,0xf0,0x5e,0x92,0x68,0x93,0xc3,0x52,0x25,0x4e,
  0xc5,0xd9,0x6c,0x38,0xbb,0x95,0xf4,0xe9,0x41,0x18,0x88,0x6b,0x6f,0xc7,0xed,0x16,
  0xeb,0xcf,0x2c,0xc1,0x2f,0xf6,0xde,0x76,0xde,0x2b,0x54,0x91,0x77,0xc7,0xe6,0xdb,
  0x3a,0x76,0xe4,0x0d,0xe5,0xe7,0xbd,0xde,0xdb,0x46,0xa6,0x95,0xd4,0xdd,0x41,0x3d,
  0xd9,0x11,0x3b,0x6c,0xb8,0xfe,0xba,0xd8,0x75,0xeb,0x98,0xac,0x8e,0xb8,0x37,0x2a,
  0x97,0x4e,0xf1,0x83,0x46,0x94,0x1f,0x17,0xfa,0x6e,0x1b,0x95,0xca,0x3c,0xf1,0x98,
  0xd3,0x27,0xfc,0xb6,0x74,0x47,0x71,0xe8,0x99,0x30,0xa0,0x82,0x40,0xd3,0xdf,0x8f,
  0x12,0x74,0x3a,0x0b,0xf7,0x22,0x22,0x6e,0x1b,0xba,0x54,0xda,0x8a,0x47,0xee,0x54,
  0xec,0x6e,0x1d,0xb2,0xdd,0x0a,0x8e,0xa8,0x8d,0x13,0x74,0x2a,0x86,0x7b,0x15,0xb7,
  0xe1,0x48,0xeb,0x94,0xba,0xcb,0xc8,0xc5,0x7d,0xec,0x2a,0x86,0x6b,0x9b,0x7a,0x1d,
  0xb7,0x8f,0x47,0x0a,0x73,0x72,0x8a,0xb8,0xda,0xa4,0xfe,0xac,0x5a,0x9e,0x62,0xc7,
  0x6d,0x74,0x39,0x0b,0x11,0x73,0x36,0xde,0x8a,0x25,0x2d,0xea,0xe8,0x62,0xc9,0x74,
  0x5a,0xfd,0x59,0x65,0x20,0x85,0x7e,0x5b,0x86,0x23,0x28,0xf2,0xc1,0x04,0x8d,0xb9,
  0x6d,0x6e,0xa0,0x4b,0x03,0x73,0x03,0xc5,0xba,0xad,0xd3,0x4d,0xa8,0xd3,0xfd,0xf6,
  0x4e,0xa8,0x9f,0x03,0xbd,0x50,0x59,0x6f,0xeb,0x86,0x9a,0x3c,0xd0,0x8d,0xa9,0xf5,
  0x6d,0x3d,0x89,0xc2,0x0f,0x74,0x25,0xda,0x7f,0x5b,0x47,0x30,0x0d,0x02,0xdd,0xc0,
  0x4e,0xd8,0xd6,0x09,0x8d,0x88,0x40,0x2f,0x6e,0x51,0x08,0x09,0x14,0xec,0x36,0x87,
  0x3f,0x69,0x64,0xf3,0xaa,0x7a,0x55,0x7a,0xf8,0xd2,0x32,0x00,0xf5,0xe7,0x56,0xf6,
  0xf1,0x7a,0x0a,0x59,0x22,0xa8,0xbe,0x93,0x25,0x88,0x88,0x06,0x44,0x83,0x76,0x14,
  0x66,0xe5,0x2b,0x59,0x93,0x74,0x6e,0xb4,0x1a,0x0e,0x87,0xe8,0x03,0x51,0x7f,0x4e,
  0x0d,0x9d,0x60,0xdf,0xa7,0x04,0x59,0x26,0x42,0x59,0x9b,0x88,0xab,0x06,0x58,0xaf,
  0x06,0x63,0xa6,0xac,0x66,0x0d,0x7c,0x45,0xbf,0x7c,0x80,0xc1,0x8a,0x53,0x30,0xf3,
  0x7b,0xfd,0x0f,0x6e,0x1d,0x1b,0x7f,0x24,0x9e,0xa5,0xdc,0x6a,0x53,0xf5,0xd6,0x70,
  0xec,0xc6,0xda,0x53,0xfd,0x35,0x25,0xcb,0x75,0x31,0x7c,0xf4,0x94,0x24,0x7e,0xe1,
  0xaa,0x0b,0x3f,0xfb,0x94,0x11,0x3c,0x20,0x34,0x06,0x65,0x51,0x2b,0x64,0xb9,0xca,
  0x80,0x8f,0x4c,0x09,0xc0,0x7b,0x90,0x61,0xf8,0x0a,0xa4,0x34,0xf9,0x42,0x05,0x28,
  0x7d,0x4e,0x65,0x5b,0xad,0xa4,0x70,0x28,0x33,0xd2,0x94,0xc9,0x13,0x68,0x23,0x48,
  0x09,0xf8,0x06,0xdb,0x1e,0xfe,0x84,0x7d,0x0c,0x8d,0x2c,0xf5,0xfe,0xf3,0x6c,0xa1,
  0xc2,0x27,0xdc,0xa1,0xf0,0x17,0x0d,0x9c,0xd0,0x6d,0x07,0xad,0xc8,0x2e,0x82,0xbf,
  0x61,0x5b,0xc0,0x4b,0xce,0xe6,0x35,0xe5,0xc9,0x23,0x82,0x8d,0x07,0xb9,0x0d,0x16,
  0x0b,0x82,0x65,0xb2,0x74,0xcd,0x4e,0x73,0xca,0x64,0xf2,0x0b,0x75,0x95,0x4e,0x7f,
  0xfa,0x9a,0xbd,0xfb,0x03,0x16,0x28,0xda,0x4e,0xfe,0xea,0x5a,0xc8,0x77,0x81,0xd5,
  0x24,0x2e,0x22,0x19,0x20,0xbf,0xba,0xb5,0xe7,0xe9,0xa8,0xfe,0x8c,0xdb,0x09,0x84,
  0x42,0x51,0x7e,0x01,0x04,0x1f,0x57,0x11,0x38,0x4a,0x24,0x98,0xe4,0xbb,0xb7,0x50,
  0x7c,0xf6,0xb6,0x2d,0x14,0xe3,0x87,0x10,0x37,0x91,0xf2,0xac,0x6d,0x43,0x5c,0x80,
  0x2b,0xcb,0x5c,0xe8,0xb6,0x96,0x57,0x0d,0x23,0x4d,0xc8,0x21,0x5c,0x1b,0x8d,0xb2,
  0xb6,0x83,0x77,0x9e,0xfc,0x3f,0x20,0xa6,0x8b,0x77,0x52,0xe2,0xf2,0xb6,0xf0,0x98,
  0x13,0x7f,0xa2,0x4c,0x0e,0x46,0x2d,0xe3,0x3b,0x40,0x8b,0xa8,0xb2,0x0b,0x14,0x8b,
  0xb4,0x8c,0x97,0x14,0xd9,0x7b,0x12,0x99,0xdc,0xd8,0x00,0xa6,0x10,0x59,0xe2,0x60,
  0xc7,0x57,0x05,0x61,0x47,0x48,0x46,0xab,0xef,0x80,0xc4,0xe0,0x61,0xa7,0xb4,0xd7,
  0x2c,0x5b,0x56,0xc8,0xb5,0xb3,0xb7,0x7b,0xbc,0xe4,0xc6,0xdb,0x3d,0x1c,0x1c,0xff,
  0x9e,0x3b,0x0b,0xe3,0x68,0xe7,0xff,0x03,0xb0,0xb6,0x16,0x39,0x63,0xcd,0x00,0x00
};


// ============================================================
//  CAMERA INIT
//  The OV2640 on AI-Thinker / HW-381 boards cannot have its
//  frame-size changed via set_framesize() while the DMA/I2S
//  capture engine is running - doing so causes FB-OVF errors.
//  The ONLY safe approach is full deinit ? reinit with the new
//  config.  initCameraMode() encapsulates that.
// ============================================================

// Build camera_config_t for a given mode
static camera_config_t buildCamConfig(framesize_t fs, int quality, int fbCount) {
  camera_config_t cfg;
  cfg.ledc_channel = LEDC_CHANNEL_0;
  cfg.ledc_timer   = LEDC_TIMER_0;
  cfg.pin_d0  = Y2_GPIO_NUM; cfg.pin_d1  = Y3_GPIO_NUM;
  cfg.pin_d2  = Y4_GPIO_NUM; cfg.pin_d3  = Y5_GPIO_NUM;
  cfg.pin_d4  = Y6_GPIO_NUM; cfg.pin_d5  = Y7_GPIO_NUM;
  cfg.pin_d6  = Y8_GPIO_NUM; cfg.pin_d7  = Y9_GPIO_NUM;
  cfg.pin_xclk     = XCLK_GPIO_NUM;
  cfg.pin_pclk     = PCLK_GPIO_NUM;
  cfg.pin_vsync    = VSYNC_GPIO_NUM;
  cfg.pin_href     = HREF_GPIO_NUM;
  cfg.pin_sccb_sda = SIOD_GPIO_NUM;
  cfg.pin_sccb_scl = SIOC_GPIO_NUM;
  cfg.pin_pwdn     = PWDN_GPIO_NUM;
  cfg.pin_reset    = RESET_GPIO_NUM;
  cfg.xclk_freq_hz = 20000000;
  cfg.pixel_format = PIXFORMAT_JPEG;
  cfg.frame_size   = fs;
  cfg.jpeg_quality = quality;
  cfg.fb_count     = fbCount;
  if (psramFound()) {
    cfg.fb_location = CAMERA_FB_IN_PSRAM;
    // LATEST mode: newest frame always available, older ones auto-discarded
    // - prevents FB-OVF during streaming
    cfg.grab_mode = (fbCount > 1) ? CAMERA_GRAB_LATEST : CAMERA_GRAB_WHEN_EMPTY;
  } else {
    cfg.fb_location = CAMERA_FB_IN_DRAM;
    cfg.grab_mode   = CAMERA_GRAB_WHEN_EMPTY;
  }
  return cfg;
}

// Full deinit + reinit - the only safe way to change resolution
bool initCameraMode(framesize_t fs, int quality, int fbCount) {
  esp_camera_deinit();
  delay(100);   // let DMA/I2S engine fully stop
  camera_config_t cfg = buildCamConfig(fs, quality, fbCount);
  esp_err_t err = esp_camera_init(&cfg);
  if (err != ESP_OK) {
    Serial.printf("[CAM] Reinit FAILED 0x%x\n", err);
    return false;
  }
  Serial.printf("[CAM] Mode: fs=%d q=%d fb=%d\n", (int)fs, quality, fbCount);
  return true;
}

// First-time init on boot (stream mode: VGA, 2 buffers for GRAB_LATEST)
bool initCamera() {
  framesize_t fs = psramFound() ? (framesize_t)streamFrameSize : FRAMESIZE_VGA;
  int quality    = psramFound() ? 10 : 12;
  int fbCount    = psramFound() ? 2  : 1;
  camera_config_t cfg = buildCamConfig(fs, quality, fbCount);
  esp_err_t err = esp_camera_init(&cfg);
  if (err != ESP_OK) { Serial.printf("📷 FAILED 0x%x\n", err); return false; }
  Serial.printf("[CAM] Boot: VGA MJPEG PSRAM=%d\n", (int)psramFound());
  return true;
}


// ============================================================
//  CAMERA SETTINGS HELPERS
// ============================================================

bool initSD() {
  if (!SD_MMC.begin("/sdcard", true)) { Serial.println("💾 Failed"); return false; }
  if (SD_MMC.cardType() == CARD_NONE) { Serial.println("💾 No card"); return false; }
  Serial.printf("[SD] Ready %.1f GB\n",
    (float)SD_MMC.totalBytes() / (1024.0*1024*1024));
  return true;
}

// ============================================================
//  HELPERS
// ============================================================
String getTimestamp() {
  struct tm ti;
  if (!getLocalTime(&ti)) {
    char buf[20]; snprintf(buf, sizeof(buf), "notime_%lu", millis()/1000);
    return String(buf);
  }
  char buf[22]; strftime(buf, sizeof(buf), "%Y-%m-%d_%H-%M-%S", &ti);
  return String(buf);
}

String getResLabel(int fs) {
  switch(fs) {
    case 1:  return "QQVGA";
    case 5:  return "QVGA";
    case 8:  return "VGA";
    case 9:  return "SVGA";
    case 10: return "XGA";
    case 11: return "HD";
    case 12: return "SXGA";
    case 13: return "UXGA";
    default: return "VGA";
  }
}

String getUptime() {
  unsigned long elapsed = (millis() - bootMs) / 1000;
  unsigned long h = elapsed / 3600;
  unsigned long m = (elapsed % 3600) / 60;
  char buf[16];
  snprintf(buf, sizeof(buf), "%luh %lum", h, m);
  return String(buf);
}

void applyStreamResolution() {
  int fbCount = psramFound() ? 2 : 1;
  initCameraMode((framesize_t)streamFrameSize, STREAM_JPEG_QUALITY, fbCount);
  Serial.printf("[CAM] Stream mode: res=%d(%s) fps=%d\n",
    streamFrameSize, getResLabel(streamFrameSize).c_str(), streamFps);
}

// Delete all files in /photos and /videos
void deleteAllSD() {
  if(sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  auto rmDir = [](const char* dir) -> int {
    int count = 0;
    File root = SD_MMC.open(dir);
    if (!root || !root.isDirectory()) return 0;
    File f = root.openNextFile();
    while (f) {
      if (!f.isDirectory()) {
        String path = String(dir) + "/" + String(f.name());
        f.close();
        SD_MMC.remove(path.c_str());
        count++;
        f = root.openNextFile();
      } else {
        f.close();  // explicitly close directory handles before moving to next entry
        f = root.openNextFile();
      }
    }
    root.close();
    return count;
  };
  int n = rmDir("/photos") + rmDir("/videos");
  if(sdMutex) xSemaphoreGive(sdMutex);
  photoCount = 0; videoCount = 0;
  Serial.printf("[SD] Deleted all: %d files\n", n);
}

int countPhotos() {
  int c=0; File r=SD_MMC.open("/photos");
  if (r&&r.isDirectory()){File f=r.openNextFile();while(f){if(!f.isDirectory())c++;f=r.openNextFile();}}
  if(r) r.close();
  return c;
}
int countVideos() {
  int c=0; File r=SD_MMC.open("/videos");
  if (r&&r.isDirectory()){File f=r.openNextFile();while(f){if(!f.isDirectory())c++;f=r.openNextFile();}}
  if(r) r.close();
  return c;
}

// ============================================================
//  ARM / DISARM  - resets warm-up and consecutive counters
// ============================================================
void armMotion() {
  motionArmed       = true;
  prevFrameReady    = false;   // force fresh baseline on first frame
  mdWarmupCount     = 0;
  mdWarmedUp        = false;
  mdConsecutive     = 0;
  Serial.println("[MD] ARMED - warm-up started");
}

void disarmMotion() {
  motionArmed    = false;
  mdWarmedUp     = false;
  mdConsecutive  = 0;
  Serial.println("[MD] DISARMED");
}

// ============================================================
//  TELEGRAM HELPERS
// ============================================================
// --- Non-blocking Telegram enqueue helpers ----------------------
void tgEnqueue(const String& msg) {
  if (!tgQueue || !telegramEnabled) return;
  TgJob job; job.type = TG_TEXT;
  strlcpy(job.text, msg.c_str(), sizeof(job.text));
  xQueueSend(tgQueue, &job, 0);
}
void tgEnqueuePhoto(const String& path, const String& cap) {
  if (!tgQueue || !telegramEnabled) return;
  TgJob job; job.type = TG_PHOTO;
  strlcpy(job.path,    path.c_str(), sizeof(job.path));
  strlcpy(job.caption, cap.c_str(),  sizeof(job.caption));
  xQueueSend(tgQueue, &job, 0);
}
void tgEnqueueVideo(const String& path, const String& cap) {
  if (!tgQueue || !telegramEnabled) return;
  TgJob job; job.type = TG_VIDEO;
  strlcpy(job.path,    path.c_str(), sizeof(job.path));
  strlcpy(job.caption, cap.c_str(),  sizeof(job.caption));
  xQueueSend(tgQueue, &job, 0);
}
// Legacy alias: all existing tgSend() call-sites compile unchanged
inline void tgSend(const String& msg) { tgEnqueue(msg); }

// --- Telegram worker - runs forever on Core 0 -------------------
// sendPhotoToTelegram / sendVideoToTelegram called ONLY from here.
void telegramTask(void*) {
  unsigned long lastPollMs = 0;
  for (;;) {
    // Use a 500ms queue timeout so we can also poll for incoming Telegram
    // commands on Core 0 without blocking Core 1's main loop at all.
    TgJob job;
    if (xQueueReceive(tgQueue, &job, pdMS_TO_TICKS(500)) == pdTRUE) {
      if (!bot || !telegramEnabled) { vTaskDelay(pdMS_TO_TICKS(10)); continue; }
      xSemaphoreTake(tgBusySem, portMAX_DELAY);
      switch (job.type) {
        case TG_TEXT:  bot->sendMessage(cfgChatID.c_str(), String(job.text), ""); break;
        case TG_PHOTO: sendPhotoToTelegram(String(job.path), String(job.caption)); break;
        case TG_VIDEO:
          vTaskDelay(pdMS_TO_TICKS(3000));
          sendVideoToTelegram(String(job.path), String(job.caption));
          break;
      }
      xSemaphoreGive(tgBusySem);
      vTaskDelay(pdMS_TO_TICKS(200));
    }

    // Poll for incoming Telegram commands here on Core 0 every 2 seconds.
    // Previously this ran in loop() on Core 1, blocking it with a full
    // HTTPS round-trip every 2s and starving the stream task.
    if (!bot || !telegramEnabled) continue;
    unsigned long now = millis();
    if (now - lastPollMs < 2000) continue;
    lastPollMs = now;
    xSemaphoreTake(tgBusySem, portMAX_DELAY);
    int n = bot->getUpdates(bot->last_message_received + 1);
    xSemaphoreGive(tgBusySem);
    while (n) {
      for (int i = 0; i < n; i++) {
        String text = bot->messages[i].text;
        if (bot->messages[i].chat_id != cfgChatID) continue;
        Serial.println("[TG] " + text);
        if (text == "/help" || text == "/start") {
          bot->sendMessage(cfgChatID.c_str(),
            "\xF0\x9F\x93\xB7 *ESP32-CAM Surveillance - Help Menu*\n\n"
            "\xF0\x9F\x93\xB8 /photo - Capture hi-res photo (no flash)\n"
            "\xE2\x9A\xA1 /photoflash - Capture hi-res photo WITH flash\n"
            "\xF0\x9F\x8E\xA5 /video - Record 10s AVI video\n"
            "\xF0\x9F\x8E\xAC /record30 - Record 30s AVI video\n"
            "\xF0\x9F\x93\x8A /status - Full system status\n"
            "\xF0\x9F\x94\x92 /arm - Arm motion detection\n"
            "\xF0\x9F\x94\x93 /disarm - Disarm motion detection\n"
            "\xF0\x9F\x92\xBE /storage - SD card storage info\n"
            "\xF0\x9F\x94\x84 /restart - Restart the ESP32\n"
            "\xE2\x9D\x93 /help - Show this menu\n\n"
            "\xF0\x9F\x92\xA1 _Dashboard: http://" + WiFi.localIP().toString() + "_", "Markdown");
        }
        else if (text == "/photo") {
          tgSend("\xF0\x9F\x93\xB8 Capturing hi-res photo (no flash)...");
          pendingJob.flash = false; pendingJob.type = JOB_PHOTO;
        }
        else if (text == "/photoflash") {
          tgSend("\xE2\x9A\xA1 Capturing hi-res photo WITH flash...");
          pendingJob.flash = true; pendingJob.type = JOB_PHOTO;
        }
        else if (text == "/video")    { pendingJob.recSecs = 10; pendingJob.type = JOB_RECORD; }
        else if (text == "/record30") { pendingJob.recSecs = 30; pendingJob.type = JOB_RECORD; }
        else if (text == "/status") {
          float temp = temperatureRead();
          unsigned long lm = (millis() - lastMotionMs) / 1000;
          bot->sendMessage(cfgChatID.c_str(),
            "\xF0\x9F\x8C\x90 *Network Status:*\n"
            "\xF0\x9F\x93\xB6 WiFi: Connected \xE2\x9C\x85\n"
            "\xF0\x9F\x93\xB1 IP: " + WiFi.localIP().toString() + "\n"
            "\xF0\x9F\x93\xA1 RSSI: " + String(WiFi.RSSI()) + " dBm\n"
            "\xF0\x9F\x8C\xA1 Temp: " + String(temp, 1) + " degC\n\n"
            "\xF0\x9F\x93\xB7 *Camera:*\n"
            "\xF0\x9F\x8E\xA5 Stream: " + getResLabel(streamFrameSize) + " @" + String(streamFps) + "fps\n"
            "\xF0\x9F\x93\xB8 Photos: " + String(photoCount) + "\n"
            "\xF0\x9F\x94\xB4 Recording: " + (aviRecording ? "ACTIVE" : "IDLE") + "\n\n"
            "\xF0\x9F\x8F\x83 *Motion Detection:*\n"
            "\xF0\x9F\x94\x8D Status: " + (motionArmed ? "ARMED \xF0\x9F\x9F\xA2" : "DISARMED \xF0\x9F\x94\xB4") + "\n"
            "\xF0\x9F\x8E\x9A Sensitivity: " + String(motionSensitivity) + "\n"
            "\xE2\x8F\xB1 Cooldown: " + String(motionCooldownS) + "s\n"
            "\xF0\x9F\x95\x90 Last alert: " + String(lm) + "s ago", "Markdown");
        }
        else if (text == "/arm")    { armMotion();    tgSend("\xF0\x9F\x94\x92 Motion *ARMED* \xF0\x9F\x9F\xA2"); }
        else if (text == "/disarm") { disarmMotion(); tgSend("\xF0\x9F\x94\x93 Motion *DISARMED*"); }
        else if (text == "/storage") {
          uint64_t tot = SD_MMC.totalBytes(), used = SD_MMC.usedBytes();
          String sdt = "Unknown";
          switch (SD_MMC.cardType()) {
            case CARD_MMC:  sdt = "MMC";        break;
            case CARD_SD:   sdt = "SDSC";       break;
            case CARD_SDHC: sdt = "SDHC/SDXC"; break;
            default: break;
          }
          bot->sendMessage(cfgChatID.c_str(),
            "\xF0\x9F\x92\xBE *SD Card:*\n"
            "Type: " + sdt + "\n"
            "Total: " + String((uint32_t)(tot / (1024*1024))) + " MB\n"
            "Used: "  + String((uint32_t)(used / (1024*1024))) + " MB\n"
            "Free: "  + String((uint32_t)((tot-used) / (1024*1024))) + " MB\n"
            "Photos: " + String(photoCount) + "  Videos: " + String(videoCount), "Markdown");
        }
        else if (text == "/restart") {
          tgSend("\xF0\x9F\x94\x84 Restarting now...");
          vTaskDelay(pdMS_TO_TICKS(500)); ESP.restart();
        }
        else { tgSend("\xE2\x9D\x93 Unknown command. Send /help for menu."); }
      }
      xSemaphoreTake(tgBusySem, portMAX_DELAY);
      n = bot->getUpdates(bot->last_message_received + 1);
      xSemaphoreGive(tgBusySem);
    }
  }
}


void sendPhotoToTelegram(const String& filePath, const String& caption) {
  if (!telegramEnabled) return;

  // Step 1: get file size under mutex (fast - just a stat)
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File fSize = SD_MMC.open(filePath.c_str(), FILE_READ);
  size_t sz = fSize ? fSize.size() : 0;
  if (fSize) fSize.close();
  if (sdMutex) xSemaphoreGive(sdMutex);
  if (sz == 0) { Serial.println("[TG] Photo: file not found or empty"); return; }

  // Step 2: TLS connect (1-3s) - NO mutex held, main loop runs freely
  // Retry up to 3 times with 2s delay - camera reinit can briefly disturb WiFi stack
  WiFiClientSecure cl; cl.setCACert(TELEGRAM_CERTIFICATE_ROOT);
  bool tlsOk = false;
  for (int attempt = 1; attempt <= 3; attempt++) {
    if (cl.connect("api.telegram.org", 443, 15000)) { tlsOk = true; break; }
    Serial.printf("[TG] Photo: TLS connect failed (attempt %d/3)\n", attempt);
    if (attempt < 3) { cl.stop(); delay(2000); }
  }
  if (!tlsOk) { Serial.println("[TG] Photo: all TLS attempts failed"); return; }


  // Step 3: send HTTP headers
  const String bd = "ESP32PB123";
  String head =
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"chat_id\"\r\n\r\n"+cfgChatID+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"caption\"\r\n\r\n"+caption+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"photo\"; filename=\"p.jpg\"\r\n"
    "Content-Type: image/jpeg\r\n\r\n";
  String tail = "\r\n--"+bd+"--\r\n";
  cl.printf("POST /bot%s/sendPhoto HTTP/1.1\r\nHost: api.telegram.org\r\n"
            "Content-Type: multipart/form-data; boundary=%s\r\n"
            "Content-Length: %u\r\nConnection: close\r\n\r\n",
            cfgBotToken.c_str(), bd.c_str(), (unsigned)(head.length()+sz+tail.length()));
  cl.print(head);

  // Step 4: stream file bytes - take mutex only for the SD read portion
  // OPT: Use 8KB chunks instead of 1KB to reduce mutex lock/unlock cycles
  // from ~200 to ~25 for a typical 200KB photo. SD bus is idle during cl.write()
  // so the tight acquire-read-release-write-acquire loop was pure overhead.
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File f = SD_MMC.open(filePath.c_str(), FILE_READ);
  if (!f) { if(sdMutex) xSemaphoreGive(sdMutex); cl.stop(); return; }
  uint8_t buf[8192];
  while (f.available()) {
    int n = f.read(buf, sizeof(buf));
    if (sdMutex) xSemaphoreGive(sdMutex);
    cl.write(buf, n);               // TLS write outside mutex
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  }
  f.close();
  if (sdMutex) xSemaphoreGive(sdMutex);

  // Step 5: send closing boundary and drain response
  cl.print(tail);
  unsigned long t=millis(); while(!cl.available()&&millis()-t<15000) delay(10);
  while(cl.available()) cl.read();
  cl.stop();
  Serial.println("[TG] Photo sent OK");
}

void sendVideoToTelegram(const String& filePath, const String& caption) {
  if (!telegramEnabled) return;
  String fname = filePath.substring(filePath.lastIndexOf('/')+1);

  // Step 1: get file size under mutex
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File fSize = SD_MMC.open(filePath.c_str(), FILE_READ);
  size_t sz = fSize ? fSize.size() : 0;
  if (fSize) fSize.close();
  if (sdMutex) xSemaphoreGive(sdMutex);
  if (sz == 0) { Serial.println("[TG] Video: file not found or empty"); return; }

  // Step 2: TLS connect - no mutex held
  // Retry up to 3 times with 2s delay - camera reinit can briefly disturb WiFi stack
  WiFiClientSecure cl; cl.setCACert(TELEGRAM_CERTIFICATE_ROOT);
  bool tlsOk = false;
  for (int attempt = 1; attempt <= 3; attempt++) {
    if (cl.connect("api.telegram.org", 443, 20000)) { tlsOk = true; break; }
    Serial.printf("[TG] Video: TLS connect failed (attempt %d/3)\n", attempt);
    if (attempt < 3) { cl.stop(); delay(2000); }
  }
  if (!tlsOk) { Serial.println("[TG] Video: all TLS attempts failed"); return; }


  // Step 3: send HTTP headers
  const String bd = "ESP32VB456";
  String head =
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"chat_id\"\r\n\r\n"+cfgChatID+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"caption\"\r\n\r\n"+caption+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"document\"; filename=\""+fname+"\"\r\n"
    "Content-Type: video/x-msvideo\r\n\r\n";
  String tail = "\r\n--"+bd+"--\r\n";
  cl.printf("POST /bot%s/sendDocument HTTP/1.1\r\nHost: api.telegram.org\r\n"
            "Content-Type: multipart/form-data; boundary=%s\r\n"
            "Content-Length: %u\r\nConnection: close\r\n\r\n",
            cfgBotToken.c_str(), bd.c_str(), (unsigned)(head.length()+sz+tail.length()));
  cl.print(head);

  // Step 4: stream file bytes - release mutex between chunks
  // vTaskDelay every 20 chunks feeds the watchdog on Core 0 during long uploads.
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File f = SD_MMC.open(filePath.c_str(), FILE_READ);
  if (!f) { if(sdMutex) xSemaphoreGive(sdMutex); cl.stop(); return; }
  uint8_t buf[2048];
  int chunkCount = 0;
  while (f.available()) {
    int n = f.read(buf, sizeof(buf));
    if (sdMutex) xSemaphoreGive(sdMutex);
    cl.write(buf, n);
    chunkCount++;
    if (chunkCount % 20 == 0) {
      vTaskDelay(pdMS_TO_TICKS(10));  // yield to IDLE0 - feeds task watchdog
    }
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  }
  f.close();
  if (sdMutex) xSemaphoreGive(sdMutex);

  // Step 5: closing boundary and drain
  cl.print(tail);
  unsigned long t=millis(); while(!cl.available()&&millis()-t<30000) delay(10);
  while(cl.available()) cl.read();
  cl.stop();
  Serial.println("[TG] Video sent OK");
}

// ============================================================
//  PHOTO CAPTURE - safe high-resolution still
//
//  Strategy: deinit camera ? reinit at UXGA ? capture ? reinit
//  back to stream config. This is the ONLY way to switch resolution
//  reliably on this hardware without FB-OVF errors.
//
//  Stream is stopped before deinit and restored after reinit.
// ============================================================
bool captureAndSavePhoto(bool sendTg, String triggerLabel, bool useFlash) {
  // -- 1. Stop stream and disarm motion ---------------------
  bool wasStreaming = streamActive;
  bool wasArmed     = motionArmed;
  streamActive = false;
  motionArmed  = false;
  delay(200);   // give httpd stream task time to finish its current frame

  // -- 2. Reinit camera at SVGA for reliable high-res still -----
  // SVGA (800x600, quality=8): 2x VGA area, fast AE settle, no blank frames.
  // UXGA was tried but caused blank frames on this hardware due to PSRAM limits.
  bool reinitOk = initCameraMode(PHOTO_FRAMESIZE, PHOTO_JPEG_QUALITY, 1);
  if (!reinitOk) {
    Serial.println("[CAM] Photo reinit failed, trying VGA fallback");
    reinitOk = initCameraMode(FRAMESIZE_VGA, PHOTO_JPEG_QUALITY, 1);
  }
  delay(350);   // OV2640 AE/AWB needs time to settle at new resolution

  // -- 3. Warm-up: discard 3 frames so AE/AWB fully settles ----
  for (int i = 0; i < 3; i++) {
    camera_fb_t* flush = esp_camera_fb_get();
    if (flush) esp_camera_fb_return(flush);
    delay(120);
  }

  // -- 4. Flash on -> discard pre-flash buffer -> capture -> flash off ----
  //
  // The OV2640 JPEG pipeline is double-buffered. When you turn the flash on
  // and immediately call esp_camera_fb_get(), you receive the frame that was
  // ALREADY being exposed before the flash fired. You need to:
  //   a) Turn flash ON
  //   b) Discard one frame (the one exposed without flash)
  //   c) Capture the next frame (now fully lit by the flash)
  //   d) Turn flash OFF
  //
  if (useFlash) {
    ledcWrite(FLASH_LED_PIN, 255);
    delay(50);   // let flash reach full brightness
    // Discard the frame that was buffered before flash fired
    camera_fb_t* preflash = esp_camera_fb_get();
    if (preflash) esp_camera_fb_return(preflash);
    delay(30);   // one extra frame period at ~15fps
  }
  camera_fb_t* fb = esp_camera_fb_get();
  if (useFlash) {
    ledcWrite(FLASH_LED_PIN, ledDuty);  // restore previous duty after flash
  }

  // -- 5. Save to SD -----------------------------------------
  bool ok = false;
  String path = "";
  if (fb) {
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
    SD_MMC.mkdir("/photos");
    path = "/photos/" + getTimestamp() + ".jpg";
    File out = SD_MMC.open(path.c_str(), FILE_WRITE);
    if (out) {
      out.write(fb->buf, fb->len);
      out.close();
      ok = true;
    }
    if (sdMutex) xSemaphoreGive(sdMutex);
    Serial.printf("[CAM] Saved %s (%u bytes, flash=%d)\n",
                  path.c_str(), (unsigned)fb->len, (int)useFlash);
    esp_camera_fb_return(fb);
    photoCount++;  // increment in-place; full rescan only at boot / deleteAllSD()
  } else {
    Serial.println("[CAM] Capture failed - fb==NULL");
  }

  // -- 6. Reinit camera back to stream mode -----------------
  {
    int fbCount = psramFound() ? 2 : 1;
    initCameraMode((framesize_t)streamFrameSize, STREAM_JPEG_QUALITY, fbCount);
  }
  delay(150);

  // Restore stream and motion state
  streamActive = wasStreaming;
  motionArmed  = wasArmed;
  if (wasArmed) { prevFrameReady = false; }   // reset motion baseline

  // -- 7. Send to Telegram with combined caption -------------
  if (ok && sendTg && telegramEnabled && bot) {
    String cap =
      "📸 Photo captured!\n"
      "📊 Photo #" + String(photoCount) + "\n"
      "💾 Saved to SD ✅\n"
      "⚡ Flash: " + (useFlash ? "ON" : "OFF") + "\n"
      "🔖 Trigger: " + triggerLabel;
    tgEnqueuePhoto(path, cap);
  }
  return ok;
}

// ============================================================
//  AVI WRITER
// ============================================================
static void writeU32LE(File& f, uint32_t v) {
  uint8_t b[4]={(uint8_t)v,(uint8_t)(v>>8),(uint8_t)(v>>16),(uint8_t)(v>>24)};
  f.write(b,4);
}
static void writeTag(File& f, const char* t){ f.write((const uint8_t*)t,4); }

// Extract actual pixel dimensions from a JPEG frame by scanning for SOF marker.
// This is the only reliable way to know the true frame size - the camera
// config framesize_t gives nominal sizes, but the actual JPEG may differ.
// OPT: Limit scan to first 512 bytes. In a well-formed OV2640 JPEG the SOF
// marker (FF C0/C2) appears within the first ~200 bytes after APP0/APP1.
// Scanning the full frame (10-30KB) risked hitting 0xFF bytes in pixel data.
static bool jpegGetDimensions(const uint8_t* buf, size_t len, int& w, int& h) {
  size_t scanLen = (len < 512) ? len : 512;
  for (size_t i = 0; i + 8 < scanLen; i++) {
    if (buf[i] == 0xFF && (buf[i+1] == 0xC0 || buf[i+1] == 0xC2)) {
      // SOF marker: FF C0/C2 <length(2)> <precision(1)> <height(2)> <width(2)>
      h = (buf[i+5] << 8) | buf[i+6];
      w = (buf[i+7] << 8) | buf[i+8];
      if (w > 0 && h > 0) return true;
    }
  }
  // Fallback: scan full frame if not found in header (non-standard JPEG)
  for (size_t i = 512; i + 8 < len; i++) {
    if (buf[i] == 0xFF && (buf[i+1] == 0xC0 || buf[i+1] == 0xC2)) {
      h = (buf[i+5] << 8) | buf[i+6];
      w = (buf[i+7] << 8) | buf[i+8];
      if (w > 0 && h > 0) return true;
    }
  }
  return false;
}

static void patchAVIHeader(File& f, int frames, int fps, int w, int h) {
  f.seek(0);
  if(fps<1)fps=1; if(fps>30)fps=30;
  uint32_t usf = 1000000u / (uint32_t)fps;
  const uint32_t avihSz=56, strhSz=56, strfSz=40;
  uint32_t strlBody = 4 + (4+4+strhSz) + (4+4+strfSz);
  uint32_t hdrlBody = 4 + (4+4+avihSz) + (4+4+strlBody);
  uint32_t maxBytes = (uint32_t)w * h * 3;

  // RIFF AVI header
  writeTag(f,"RIFF"); writeU32LE(f,(uint32_t)f.size()-8); writeTag(f,"AVI ");

  // hdrl LIST
  writeTag(f,"LIST"); writeU32LE(f,hdrlBody); writeTag(f,"hdrl");

  // avih - Main AVI header (56 bytes)
  writeTag(f,"avih"); writeU32LE(f,avihSz);
  writeU32LE(f,usf);          // dwMicroSecPerFrame
  writeU32LE(f,maxBytes);     // dwMaxBytesPerSec
  writeU32LE(f,0);            // dwPaddingGranularity
  writeU32LE(f,0x00);         // dwFlags: 0 (no idx1 chunk written, so AVIF_HASINDEX must NOT be set)
  writeU32LE(f,(uint32_t)frames); // dwTotalFrames
  writeU32LE(f,0);            // dwInitialFrames
  writeU32LE(f,1);            // dwStreams
  writeU32LE(f,maxBytes);     // dwSuggestedBufferSize
  writeU32LE(f,(uint32_t)w);  // dwWidth
  writeU32LE(f,(uint32_t)h);  // dwHeight
  for(int i=0;i<4;i++) writeU32LE(f,0); // reserved[4]

  // strl LIST (stream list)
  writeTag(f,"LIST"); writeU32LE(f,strlBody); writeTag(f,"strl");

  // strh - Stream header (56 bytes)
  writeTag(f,"strh"); writeU32LE(f,strhSz);
  writeTag(f,"vids");         // fccType: video stream
  writeTag(f,"MJPG");         // fccHandler: MJPEG codec
  writeU32LE(f,0);            // dwFlags
  writeU32LE(f,0);            // wPriority + wLanguage
  writeU32LE(f,0);            // dwInitialFrames
  writeU32LE(f,1);            // dwScale (time base numerator)
  writeU32LE(f,(uint32_t)fps);// dwRate  (frames per second)
  writeU32LE(f,0);            // dwStart
  writeU32LE(f,(uint32_t)frames); // dwLength
  writeU32LE(f,maxBytes);     // dwSuggestedBufferSize
  writeU32LE(f,0xFFFFFFFF);   // dwQuality (-1 = default)
  writeU32LE(f,0);            // dwSampleSize (0 = variable)
  // rcFrame: {left=0, top=0, right=w, bottom=h} as two 32-bit LE words
  writeU32LE(f,0);                          // left(16) | top(16)
  writeU32LE(f,((uint32_t)h<<16)|(uint32_t)w); // right(16) | bottom(16) -- actually bottom(16)|right(16)

  // strf - BITMAPINFOHEADER (40 bytes) for MJPEG video stream
  writeTag(f,"strf"); writeU32LE(f,strfSz);
  writeU32LE(f,strfSz);            // biSize
  writeU32LE(f,(uint32_t)w);       // biWidth
  // biHeight: NEGATIVE value signals top-down row order (required for MJPEG).
  // Without this, many players assume bottom-up and display incorrectly.
  // Store as two's complement uint32.
  writeU32LE(f,(uint32_t)(-(int32_t)h)); // biHeight (negative = top-down)
  writeU32LE(f,1u|(24u<<16));      // biPlanes=1, biBitCount=24
  writeTag(f,"MJPG");              // biCompression
  writeU32LE(f,maxBytes);          // biSizeImage
  writeU32LE(f,0);                 // biXPelsPerMeter
  writeU32LE(f,0);                 // biYPelsPerMeter
  writeU32LE(f,0);                 // biClrUsed
  writeU32LE(f,0);                 // biClrImportant
}

#define AVI_HDR_RESERVE 256
bool startAVIRecording(int durationSec) {
  if(aviRecording) return false;
  // Check free space: estimate ~150 MB max for a 120s recording; require at least 200 MB free
  uint64_t freeBytes = SD_MMC.totalBytes() - SD_MMC.usedBytes();
  if (freeBytes < 200ULL * 1024 * 1024) {
    Serial.printf("[AVI] Insufficient SD space: %.0f MB free\n", freeBytes / 1048576.0f);
    tgSend("SD card almost full - recording aborted. Free space: "
      + String((uint32_t)(freeBytes / 1048576)) + " MB");
    return false;
  }
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  SD_MMC.mkdir("/videos");
  // Filename: YYYY-MM-DD_HH-MM-SS_<RES>_<DUR>s.avi
  String path = "/videos/" + getTimestamp() + "_" + getResLabel(streamFrameSize)
                + "_" + String(durationSec) + "s.avi";
  strncpy(aviFilePath, path.c_str(), sizeof(aviFilePath)-1);
  aviFile = SD_MMC.open(aviFilePath, FILE_WRITE);
  if(!aviFile){ if(sdMutex) xSemaphoreGive(sdMutex); Serial.println("[AVI] Open failed"); return false; }
  uint8_t zeros[AVI_HDR_RESERVE]={};
  aviFile.write(zeros, AVI_HDR_RESERVE);
  aviMoviOffset = (uint32_t)aviFile.position();
  writeTag(aviFile,"LIST"); writeU32LE(aviFile,0); writeTag(aviFile,"movi");
  aviFrameCount = 0; aviStartMs = millis(); aviRecording = true;
  aviWidth = 640; aviHeight = 480;  // defaults - updated from first real frame
  Serial.printf("[AVI] Start %s\n", aviFilePath);
  return true;
}

bool addAVIFrame(camera_fb_t* fb){
  if(!aviRecording||!fb||aviFrameCount>=AVI_MAX_FRAMES) return false;
  // Extract actual frame dimensions from first frame
  if(aviFrameCount == 0) {
    int fw=0, fh=0;
    if(jpegGetDimensions(fb->buf, fb->len, fw, fh) && fw>0 && fh>0) {
      aviWidth = fw; aviHeight = fh;
      Serial.printf("[AVI] Frame dims from JPEG: %dx%d\n", fw, fh);
    }
  }
  aviFrameCount++;
  writeTag(aviFile,"00dc"); writeU32LE(aviFile,fb->len);
  aviFile.write(fb->buf,fb->len);
  if(fb->len&1) aviFile.write((uint8_t)0);
  return true;
}

String finishAVIRecording(){
  if(!aviRecording) return "";
  aviRecording=false;
  unsigned long dur=millis()-aviStartMs;
  int fps=(dur>0)?(int)((aviFrameCount*1000UL)/dur):5;
  if(fps<1)fps=1; if(fps>30)fps=30;
  uint32_t end=(uint32_t)aviFile.size();
  uint32_t moviBody=end-aviMoviOffset-8;
  aviFile.seek(aviMoviOffset+4); writeU32LE(aviFile,moviBody+4);
  // Use actual detected dimensions - correct aspect ratio in any player
  patchAVIHeader(aviFile, aviFrameCount, fps, aviWidth, aviHeight);
  aviFile.close();
  if (sdMutex) xSemaphoreGive(sdMutex);
  videoCount++;  // increment in-place; full rescan only at boot / deleteAllSD()
  Serial.printf("[AVI] Done %d frames %dfps %dx%d\n",
    aviFrameCount, fps, aviWidth, aviHeight);
  return String(aviFilePath);
}

// ============================================================
//  MOTION DETECTION  - v2.2 complete rewrite
//
//  Algorithm: Mean Absolute Difference (MAD) on grayscale frames
//
//  Why MAD works better than pixel-count:
//    ? JPEG noise causes tiny random differences on EVERY pixel
//    ? Counting "pixels > threshold" catches ALL of them ? floods
//    ? MAD averages all differences ? JPEG noise averages to ~0-3
//    ? Real motion creates large per-pixel differences ? MAD spikes
//
//  Extra guards:
//    1. Warm-up: first MD_WARMUP_FRAMES frames after arming are
//       discarded so the sensor and AE settle (eliminates boot floods)
//    2. Consecutive: motion fires only after MD_CONSEC_REQUIRED
//       successive frames both exceed the threshold (eliminates
//       single-frame compression artefact triggers)
// ============================================================

// Decode JPEG to grayscale at 1/8 scale -> 80x60
// Uses jpg2rgb565 then converts RGB565->gray via a precomputed LUT.
//
// OPT: Two 256-entry lookup tables replace the per-pixel multiply chain.
//   hiLUT[hi] = R contribution + upper-G contribution to BT.601 luma
//   loLUT[lo] = lower-G contribution + B contribution to BT.601 luma
//   luma = clamp(hiLUT[hi] + loLUT[lo], 255)
// Cost per pixel: 2 table lookups + 1 add  (was: 6 shifts, 4 ORs, 3 muls)
// ~40% faster on Xtensa LX6 at 240 MHz.
static bool     grayLUTReady = false;
static uint8_t  hiLUT[256];   // R + upper-G luma contribution indexed by hi byte
static uint8_t  loLUT[256];   // lower-G + B luma contribution indexed by lo byte

static void buildGrayLUT() {
  if (grayLUTReady) return;
  // hi byte layout: RRRRRGGG  (R5 in bits[7:3], G_hi3 in bits[2:0])
  for (int hi = 0; hi < 256; hi++) {
    uint8_t r5  = (hi >> 3) & 0x1F;
    uint8_t gh3 = hi & 0x07;             // top 3 bits of G6
    uint8_t r8  = (r5 << 3) | (r5 >> 2);
    uint8_t g6h = gh3 << 3;              // bottom 3 G bits contributed by loLUT
    uint8_t g8h = (g6h << 2) | (g6h >> 4);
    uint16_t v  = (77u * r8 + 150u * g8h) >> 8;
    hiLUT[hi]   = (uint8_t)(v > 255 ? 255 : v);
  }
  // lo byte layout: GGGBBBBB  (G_lo3 in bits[7:5], B5 in bits[4:0])
  for (int lo = 0; lo < 256; lo++) {
    uint8_t gl3 = (lo >> 5) & 0x07;     // bottom 3 bits of G6
    uint8_t b5  = lo & 0x1F;
    uint8_t b8  = (b5 << 3) | (b5 >> 2);
    uint8_t g6l = gl3;
    uint8_t g8l = (g6l << 2) | (g6l >> 4);
    uint16_t v  = (150u * g8l + 29u * b8) >> 8;
    loLUT[lo]   = (uint8_t)(v > 255 ? 255 : v);
  }
  grayLUTReady = true;
}

static bool decodeToGray(camera_fb_t* fb, uint8_t* grayOut) {
  static uint8_t* rgb565Tmp = nullptr;
  const size_t tmpSz = MD_PIXELS * 2;

  if (!rgb565Tmp) {
    rgb565Tmp = psramFound()
      ? (uint8_t*)ps_malloc(tmpSz)
      : (uint8_t*)malloc(tmpSz);
    if (!rgb565Tmp) {
      Serial.println("[MD] decodeToGray: buffer alloc failed - motion disabled");
      return false;
    }
  }

  buildGrayLUT();  // no-op after first call

  if (!jpg2rgb565(fb->buf, fb->len, rgb565Tmp, JPG_SCALE_8X)) return false;

  // OPT: LUT lookup - 2 reads + 1 add per pixel replaces full multiply chain
  const uint8_t* src = rgb565Tmp;
  for (int i = 0; i < MD_PIXELS; i++) {
    uint16_t luma = (uint16_t)hiLUT[src[0]] + (uint16_t)loLUT[src[1]];
    grayOut[i] = (luma > 255) ? 255 : (uint8_t)luma;
    src += 2;
  }
  return true;
}

bool checkMotion(camera_fb_t* fb) {
  // Guard: armed, buffers ready, not recording
  if (!motionArmed || !prevGray || !currGray) return false;

  // Decode current frame to grayscale
  if (!decodeToGray(fb, currGray)) return false;

  // Warm-up phase: accumulate baseline frames, don't trigger.
  // OPT: Only memcpy on the LAST warm-up frame - previous copies were
  // immediately overwritten by the next frame's decode, so they were wasted.
  if (!mdWarmedUp) {
    mdWarmupCount++;
    if (mdWarmupCount >= MD_WARMUP_FRAMES) {
      // Final warm-up frame: latch it as the baseline and go active
      memcpy(prevGray, currGray, MD_PIXELS);
      prevFrameReady = true;
      mdWarmedUp = true;
      Serial.println("[MD] Warm-up complete - detection active");
    } else {
      Serial.printf("[MD] Warm-up %d/%d\n", mdWarmupCount, MD_WARMUP_FRAMES);
    }
    return false;
  }

  if (!prevFrameReady) {
    memcpy(prevGray, currGray, MD_PIXELS);
    prevFrameReady = true;
    return false;
  }

  // Compute Mean Absolute Difference across all pixels
  uint32_t sumDiff = 0;
  for (int i = 0; i < MD_PIXELS; i++) {
    sumDiff += (uint32_t)abs((int)currGray[i] - (int)prevGray[i]);
  }
  float mad = (float)sumDiff / MD_PIXELS;

  // Update previous frame
  memcpy(prevGray, currGray, MD_PIXELS);

  // Throttle serial output: print idle MAD at most once every 5 seconds
  static unsigned long lastMadPrintMs = 0;
  if (millis() - lastMadPrintMs >= 5000) {
    Serial.printf("[MD] MAD=%.2f threshold=%.2f\n", mad, mdThreshold);
    lastMadPrintMs = millis();
  }

  // Check against threshold
  if (mad > mdThreshold) {
    mdConsecutive++;
    Serial.printf("[MD] Hit %d/%d (MAD=%.2f)\n",
      mdConsecutive, MD_CONSEC_REQUIRED, mad);
    if (mdConsecutive >= MD_CONSEC_REQUIRED) {
      mdConsecutive = 0;   // reset for next event
      return true;         // REAL MOTION CONFIRMED
    }
  } else {
    // Reset consecutive counter if frame is calm
    mdConsecutive = 0;
  }
  return false;
}

// ============================================================
//  MJPEG STREAM SERVER  (port 81)
// ============================================================
#define STREAM_BD "ESP32SBound"
static const char* STREAM_CT   = "multipart/x-mixed-replace;boundary=" STREAM_BD;
// X-Timestamp matches CameraWebServer format - some clients use it for sync
static const char* STREAM_PART = "Content-Type: image/jpeg\r\nContent-Length: %u\r\nX-Timestamp: %d.%06d\r\n\r\n";

static esp_err_t streamHandler(httpd_req_t* req) {
  if (!streamActive) { httpd_resp_send_404(req); return ESP_OK; }
  httpd_resp_set_type(req, STREAM_CT);
  httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
  httpd_resp_set_hdr(req, "X-Framerate", "60");
  const char* bnd = "\r\n--" STREAM_BD "\r\n";
  char hdr[128];  // enlarged to fit X-Timestamp

  int64_t frameIntervalUs = (streamFps > 0) ? (1000000 / streamFps) : 100000;
  int64_t lastFrameUs = esp_timer_get_time();

  while (streamActive) {
    camera_fb_t* fb = esp_camera_fb_get();
    if (!fb) break;
    httpd_resp_send_chunk(req, bnd, strlen(bnd));
    size_t hl = snprintf(hdr, sizeof(hdr), STREAM_PART, fb->len,
                         (int)fb->timestamp.tv_sec, (int)fb->timestamp.tv_usec);
    httpd_resp_send_chunk(req, hdr, hl);
    esp_err_t r = httpd_resp_send_chunk(req, (const char*)fb->buf, fb->len);
    esp_camera_fb_return(fb);
    if (r != ESP_OK) break;
    int64_t now = esp_timer_get_time();
    int64_t elapsed = now - lastFrameUs;
    if (elapsed < frameIntervalUs) {
      vTaskDelay(pdMS_TO_TICKS((frameIntervalUs - elapsed) / 1000));
    }
    lastFrameUs = esp_timer_get_time();
  }
  return ESP_OK;
}

void startStreamServer() {
  httpd_config_t cfg = HTTPD_DEFAULT_CONFIG();
  cfg.server_port    = 81;
  cfg.ctrl_port      = 32769;
  cfg.max_uri_handlers = 2;
  cfg.stack_size     = 8192;   // CameraWebServer uses 8KB stack for stream task
  cfg.send_wait_timeout = 10;  // seconds - prevents slow clients from blocking
  httpd_uri_t u = {"/stream", HTTP_GET, streamHandler, nullptr};
  if (httpd_start(&streamHttpd, &cfg) == ESP_OK) {
    httpd_register_uri_handler(streamHttpd, &u);
    Serial.println("[STREAM] :81/stream ready");
  }
}

// ============================================================
//  WEB SERVER  (port 80)
// ============================================================
void apiStatus() {
  float temp = temperatureRead();
  const char* rl[] = {
    "96x96","QQVGA","QCIF","HQVGA","240x240","QVGA 320x240","CIF 400x296",
    "HVGA 480x320","VGA 640x480","SVGA 800x600","XGA 1024x768",
    "HD 1280x720","SXGA 1280x1024","UXGA 1600x1200"
  };
  String resLabel = (streamFrameSize>=0&&streamFrameSize<=13) ? rl[streamFrameSize] : "VGA 640x480";
  StaticJsonDocument<640> doc;
  doc["uptime"]       = getUptime();
  doc["wifi"]         = (WiFi.status()==WL_CONNECTED);
  doc["ip"]           = WiFi.localIP().toString();
  doc["rssi"]         = WiFi.RSSI();
  doc["temp"]         = String(temp,1);
  doc["resolution"]   = resLabel + " @" + String(streamFps) + "fps";
  doc["streamRes"]    = streamFrameSize;
  doc["streamFps"]    = streamFps;
  doc["photos"]       = photoCount;
  doc["videos"]       = videoCount;
  doc["armed"]        = motionArmed;
  doc["warmedUp"]     = mdWarmedUp;
  doc["sensitivity"]  = motionSensitivity;
  doc["cooldown"]     = motionCooldownS;
  doc["recording"]    = aviRecording;
  doc["telegram"]     = telegramEnabled;
  doc["timelapse"]    = timelapseActive;
  doc["tlInterval"]   = timelapseIntervalS;
  doc["emailEnabled"] = emailEnabled;
  doc["freeHeap"]     = (uint32_t)(ESP.getFreeHeap()/1024);
  doc["freePsram"]    = (uint32_t)(ESP.getFreePsram()/1024);
  String out; serializeJson(doc,out);
  webServer.send(200,"application/json",out);
}

// ============================================================
//  /api/sdstats -- SD FAT queries on user demand only
// ============================================================
void apiSdStats() {
  uint64_t tot=SD_MMC.totalBytes(), used=SD_MMC.usedBytes();
  String t="Unknown";
  switch(SD_MMC.cardType()){
    case CARD_MMC:  t="MMC";        break;
    case CARD_SD:   t="SDSC";       break;
    case CARD_SDHC: t="SDHC/SDXC"; break;
    default: break;
  }
  StaticJsonDocument<192> doc;
  doc["sdType"]  = t;
  doc["sdTotal"] = (uint32_t)(tot/1048576);
  doc["sdUsed"]  = (uint32_t)(used/1048576);
  doc["sdFree"]  = (uint32_t)((tot-used)/1048576);
  String out; serializeJson(doc,out);
  webServer.send(200,"application/json",out);
}


// NEW: dedicated motion arm/disarm endpoint
void apiMotion() {
  if (webServer.hasArg("armed")) {
    int v = webServer.arg("armed").toInt();
    if (v) armMotion(); else disarmMotion();
  }
  webServer.send(200,"application/json",
    String("{\"armed\":")+( motionArmed?"true":"false")+"}");
}

// GET /api/timelapse?active=1&interval=30
void apiTimelapse() {
  if (webServer.hasArg("active")) {
    timelapseActive = webServer.arg("active").toInt() != 0;
    if (timelapseActive) lastTimelapseMs = 0; // fire first capture immediately
    Serial.printf("[TL] Timelapse %s\n", timelapseActive ? "STARTED" : "STOPPED");
  }
  if (webServer.hasArg("interval")) {
    timelapseIntervalS = constrain(webServer.arg("interval").toInt(), 1, 3600);
    Serial.printf("[TL] Interval set to %ds\n", timelapseIntervalS);
  }
  preferences.begin("surveil", false);
  preferences.putBool("tlActive",   timelapseActive);
  preferences.putInt ("tlInterval", timelapseIntervalS);
  preferences.end();
  webServer.send(200,"application/json",
    String("{\"active\":") + (timelapseActive?"true":"false") +
    ",\"interval\":" + String(timelapseIntervalS) + "}");
}

// Photo handler: schedule work in loop() and return immediately.
// captureAndSavePhoto() takes ~2s - we must not block handleClient().
void apiPhoto() {
  if (pendingJob.type != JOB_NONE) {
    webServer.send(503,"application/json","{\"ok\":false,\"error\":\"Busy\"}"); return;
  }
  pendingJob.flash = webServer.hasArg("flash") && webServer.arg("flash") == "1";
  pendingJob.type  = JOB_PHOTO;
  webServer.send(200,"application/json","{\"ok\":true,\"queued\":true}");
}

void apiStreamStart() {
  // Accept optional res/fps overrides from the start request
  if (webServer.hasArg("res")) {
    int r = webServer.arg("res").toInt();
    if (r >= 0 && r <= 13) { streamFrameSize = r; }
  }
  if (webServer.hasArg("fps")) {
    int f = webServer.arg("fps").toInt();
    if (f >= 1 && f <= 30) { streamFps = f; }
  }
  // Stop stream while we reinit camera (safe - nothing streaming yet)
  streamActive = false;
  delay(100);
  applyStreamResolution();
  delay(150);
  streamActive = true;
  webServer.send(200,"application/json","{\"ok\":true}");
}
void apiStreamStop() {
  streamActive = false;
  delay(150);   // let stream handler exit its loop
  webServer.send(200,"application/json","{\"ok\":true}");
}

void apiStreamQuality() {
  bool wasStreaming = streamActive;
  // Stop stream before changing resolution
  if (wasStreaming) {
    streamActive = false;
    delay(200);   // let httpd task finish current frame
  }
  if (webServer.hasArg("res")) {
    int r = webServer.arg("res").toInt();
    if (r >= 0 && r <= 13) { streamFrameSize = r; }
  }
  if (webServer.hasArg("fps")) {
    int f = webServer.arg("fps").toInt();
    if (f >= 1 && f <= 30) { streamFps = f; }
  }
  // Reinit camera at new resolution
  applyStreamResolution();
  delay(100);
  if (wasStreaming) { streamActive = true; }
  webServer.send(200,"application/json","{\"ok\":true}");
}

void apiRestart() {
  webServer.send(200,"application/json","{\"ok\":true}");
  delay(300);
  ESP.restart();
}

// Record handler: schedule work in loop() and return immediately.
// Recording takes 5-120s - blocking handleClient() would freeze dashboard.
void apiRecord(){
  int secs=webServer.hasArg("secs")?webServer.arg("secs").toInt():10;
  secs=constrain(secs,5,120);
  if(aviRecording||pendingJob.type!=JOB_NONE){
    webServer.send(200,"application/json","{\"ok\":false,\"error\":\"Busy\"}"); return;
  }
  pendingJob.recSecs = secs;
  pendingJob.type    = JOB_RECORD;
  webServer.send(200,"application/json","{\"ok\":true,\"queued\":true,\"secs\":"+String(secs)+"}");
}

// OPT: Cached file list - rebuilt only when photoCount or videoCount changes.
// The SD directory scan + sort is O(n log n) flash I/O; for typical use the
// file list is stable between captures so we serve the cached result.
struct FileEntry { char name[64]; char path[96]; size_t size; };
static std::vector<FileEntry> eventsCache;

static void rebuildEventsCache() {
  eventsCache.clear();
  eventsCache.reserve(64);
  auto scanDir = [](const char* dir) {
    File root = SD_MMC.open(dir);
    if (!root || !root.isDirectory()) return;
    File f = root.openNextFile();
    while (f) {
      if (!f.isDirectory()) {
        FileEntry e;
        strlcpy(e.name, f.name(),    sizeof(e.name));
        snprintf(e.path, sizeof(e.path), "%s/%s", dir, f.name());
        e.size = f.size();
        eventsCache.push_back(e);
      }
      f = root.openNextFile();
    }
    root.close();
  };
  scanDir("/photos");
  scanDir("/videos");
  std::sort(eventsCache.begin(), eventsCache.end(),
    [](const FileEntry& a, const FileEntry& b){ return strcmp(a.name, b.name) > 0; });
  eventsCachePhotoSnap = photoCount;
  eventsCacheVideoSnap = videoCount;
  eventsCacheDirty     = false;
}

void apiEvents(){
  int offset = webServer.hasArg("offset") ? webServer.arg("offset").toInt() : 0;
  int limit  = webServer.hasArg("limit")  ? webServer.arg("limit").toInt()  : EVENTS_PAGE_SIZE;
  limit = constrain(limit, 1, 100);

  // OPT: Only rescan SD when the file list has changed (dirty flag or count mismatch).
  if (eventsCacheDirty ||
      photoCount != eventsCachePhotoSnap ||
      videoCount != eventsCacheVideoSnap) {
    rebuildEventsCache();
  }

  int total = (int)eventsCache.size();
  DynamicJsonDocument doc(8192);
  doc["total"] = total;
  JsonArray arr = doc.createNestedArray("files");

  int end = min(offset + limit, total);
  for (int i = offset; i < end; i++) {
    JsonObject o = arr.createNestedObject();
    o["name"] = eventsCache[i].name;
    o["path"] = eventsCache[i].path;
    o["size"] = String(eventsCache[i].size / 1024) + " KB";
  }
  String out; serializeJson(doc, out);
  webServer.send(200, "application/json", out);
}

void apiDeleteAll() {
  int before = photoCount + videoCount;  // capture before deleteAllSD() resets counters
  deleteAllSD();
  eventsCacheDirty = true;  // OPT: force events cache rebuild after mass delete
  webServer.send(200, "application/json",
    "{\"ok\":true,\"count\":" + String(before) + "}");
}

void apiDownload(){
  if(!webServer.hasArg("f")){webServer.send(400,"text/plain","Missing f");return;}
  String path=webServer.arg("f");
  if(!path.startsWith("/photos/")&&!path.startsWith("/videos/")){webServer.send(403,"text/plain","Forbidden");return;}
  File f=SD_MMC.open(path.c_str(),FILE_READ);
  if(!f){webServer.send(404,"text/plain","Not found");return;}
  bool jpg=path.endsWith(".jpg")||path.endsWith(".jpeg");
  webServer.sendHeader("Content-Disposition","attachment; filename=\""+path.substring(path.lastIndexOf('/')+1)+"\"");
  webServer.streamFile(f,jpg?"image/jpeg":"video/x-msvideo"); f.close();
}
void apiThumb(){
  if(!webServer.hasArg("f")){webServer.send(404,"text/plain","No f");return;}
  String path=webServer.arg("f");
  if(!path.startsWith("/photos/")){webServer.send(403,"text/plain","Forbidden");return;}
  File f=SD_MMC.open(path.c_str(),FILE_READ);
  if(!f){webServer.send(404,"text/plain","Not found");return;}
  webServer.streamFile(f,"image/jpeg"); f.close();
}
void apiDelete(){
  if(!webServer.hasArg("f")){webServer.send(400,"application/json","{\"ok\":false}");return;}
  String path=webServer.arg("f");
  if(!path.startsWith("/photos/")&&!path.startsWith("/videos/")){webServer.send(403,"application/json","{\"ok\":false}");return;}
  bool ok=SD_MMC.remove(path.c_str());
  if(ok){
    if(path.startsWith("/photos/")) photoCount = max(0, photoCount - 1);
    else                            videoCount = max(0, videoCount - 1);
  }
  webServer.send(200,"application/json",ok?"{\"ok\":true}":"{\"ok\":false,\"error\":\"Delete failed\"}");
}
void apiConfig(){
  if(webServer.method()==HTTP_POST){
    StaticJsonDocument<768> doc;
    if(deserializeJson(doc,webServer.arg("plain"))){
      webServer.send(400,"application/json","{\"ok\":false}"); return;
    }
    bool needReboot = false;
    // Update in-RAM values immediately (these are used by the running system)
    if(doc.containsKey("sensitivity")){
      motionSensitivity=(int)doc["sensitivity"];
      mdThreshold=sliderToThreshold(motionSensitivity);
    }
    if(doc.containsKey("cooldown")){
      motionCooldownS=(int)doc["cooldown"];
    }
    if(doc.containsKey("wifiSSID")) needReboot=true;
    if(doc.containsKey("wifiPass")) needReboot=true;
    if(doc.containsKey("botToken")) needReboot=true;
    if(doc.containsKey("chatID"))   needReboot=true;
    // OPT: Send HTTP response BEFORE NVS flash writes.
    // Client gets its 200 OK instantly; NVS erase/write (~5-15ms per key)
    // happens after the TCP stack has queued the response bytes.
    // OPT: Single preferences.begin()/end() for all keys (was one open/close per key).
    webServer.send(200,"application/json",
      needReboot ? "{\"ok\":true,\"reboot\":true}" : "{\"ok\":true,\"reboot\":false}");
    preferences.begin("surveil", false);
    if(doc.containsKey("sensitivity")) preferences.putInt("motionSens", motionSensitivity);
    if(doc.containsKey("cooldown"))    preferences.putInt("motionCool", motionCooldownS);
    if(doc.containsKey("wifiSSID"))    preferences.putString("wifiSSID", doc["wifiSSID"].as<String>());
    if(doc.containsKey("wifiPass"))    preferences.putString("wifiPass", doc["wifiPass"].as<String>());
    if(doc.containsKey("botToken"))    preferences.putString("botToken", doc["botToken"].as<String>());
    if(doc.containsKey("chatID"))      preferences.putString("chatID",   doc["chatID"].as<String>());
    preferences.end();
    if(needReboot){ delay(800); ESP.restart(); }
  } else {
    StaticJsonDocument<512> doc;
    doc["sensitivity"]  = motionSensitivity;
    doc["cooldown"]     = motionCooldownS;
    preferences.begin("surveil", true);
    doc["wifiSSID"]     = preferences.getString("wifiSSID","");
    doc["tgConfigured"] = (preferences.getString("botToken","").length() > 0);
    preferences.end();
    doc["apMode"]       = apMode;
    String out; serializeJson(doc,out);
    webServer.send(200,"application/json",out);
  }
}


// ============================================================
//  CAMERA CONTROL - exact CameraWebServer approach
//  GET /control?var=brightness&val=2
//  One request per variable, direct sensor register write.
//  No JSON, no mutex, no stream stop. Works exactly like the
//  official Espressif CameraWebServer example.
// ============================================================
void apiCamControl() {
  if (!webServer.hasArg("var") || !webServer.hasArg("val")) {
    webServer.send(400, "text/plain", "Missing var or val"); return;
  }
  String var = webServer.arg("var");
  int    val = webServer.arg("val").toInt();
  sensor_t* s = esp_camera_sensor_get();
  if (!s) { webServer.send(500, "text/plain", "No sensor"); return; }

  int res = 0;
  if      (var == "framesize")     { if (s->pixformat == PIXFORMAT_JPEG) res = s->set_framesize(s, (framesize_t)val); }
  else if (var == "quality")       res = s->set_quality(s, val);
  else if (var == "contrast")      res = s->set_contrast(s, val);
  else if (var == "brightness")    res = s->set_brightness(s, val);
  else if (var == "saturation")    res = s->set_saturation(s, val);
  else if (var == "gainceiling")   res = s->set_gainceiling(s, (gainceiling_t)val);
  else if (var == "colorbar")      res = s->set_colorbar(s, val);
  else if (var == "awb")           res = s->set_whitebal(s, val);
  else if (var == "agc")           res = s->set_gain_ctrl(s, val);
  else if (var == "aec")           res = s->set_exposure_ctrl(s, val);
  else if (var == "hmirror")       res = s->set_hmirror(s, val);
  else if (var == "vflip")         res = s->set_vflip(s, val);
  else if (var == "awb_gain")      res = s->set_awb_gain(s, val);
  else if (var == "agc_gain")      res = s->set_agc_gain(s, val);
  else if (var == "aec_value")     res = s->set_aec_value(s, val);
  else if (var == "aec2")          res = s->set_aec2(s, val);
  else if (var == "dcw")           res = s->set_dcw(s, val);
  else if (var == "bpc")           res = s->set_bpc(s, val);
  else if (var == "wpc")           res = s->set_wpc(s, val);
  else if (var == "raw_gma")       res = s->set_raw_gma(s, val);
  else if (var == "lenc")          res = s->set_lenc(s, val);
  else if (var == "special_effect")res = s->set_special_effect(s, val);
  else if (var == "wb_mode")       res = s->set_wb_mode(s, val);
  else if (var == "ae_level")      res = s->set_ae_level(s, val);
  else if (var == "sharpness")     res = s->set_sharpness(s, val);
  else if (var == "led_intensity") {
    // LED intensity via LEDC PWM - same as CameraWebServer enable_led().
    // ledcWrite(pin, 0) fully cuts PWM output; no digitalWrite needed.
    ledDuty = constrain(val, 0, 255);
    ledcWrite(FLASH_LED_PIN, ledDuty);
    Serial.printf("[CAM] control: led_intensity = %d\n", ledDuty);
    webServer.send(200, "text/plain", "OK"); return;
  }
  else { webServer.send(404, "text/plain", "Unknown var"); return; }

  Serial.printf("[CAM] control: %s = %d (res=%d)\n", var.c_str(), val, res);
  if (res < 0) { webServer.send(500, "text/plain", "Sensor error"); return; }
  webServer.send(200, "text/plain", "OK");
}

// GET /xclk?xclk=20 - set XCLK frequency in MHz, same as CameraWebServer
void apiXclk() {
  if (!webServer.hasArg("xclk")) { webServer.send(400, "text/plain", "Missing xclk"); return; }
  int xclk = webServer.arg("xclk").toInt();
  xclk = constrain(xclk, 2, 40);
  sensor_t* s = esp_camera_sensor_get();
  if (!s) { webServer.send(500, "text/plain", "No sensor"); return; }
  int res = s->set_xclk(s, LEDC_TIMER_0, xclk);
  Serial.printf("[CAM] XCLK set to %d MHz (res=%d)\n", xclk, res);
  if (res != 0) { webServer.send(500, "text/plain", "XCLK error"); return; }
  webServer.send(200, "text/plain", "OK");
}

// GET /camstatus - reads actual sensor register values, same as CameraWebServer /status
// Dashboard calls this on load to populate all sliders with real current values.
void apiCamStatus() {
  sensor_t* s = esp_camera_sensor_get();
  if (!s) { webServer.send(500, "application/json", "{}"); return; }
  StaticJsonDocument<768> doc;
  doc["framesize"]      = s->status.framesize;
  doc["quality"]        = s->status.quality;
  doc["brightness"]     = s->status.brightness;
  doc["contrast"]       = s->status.contrast;
  doc["saturation"]     = s->status.saturation;
  doc["sharpness"]      = s->status.sharpness;
  doc["special_effect"] = s->status.special_effect;
  doc["wb_mode"]        = s->status.wb_mode;
  doc["awb"]            = s->status.awb;
  doc["awb_gain"]       = s->status.awb_gain;
  doc["aec"]            = s->status.aec;
  doc["aec2"]           = s->status.aec2;
  doc["ae_level"]       = s->status.ae_level;
  doc["aec_value"]      = s->status.aec_value;
  doc["agc"]            = s->status.agc;
  doc["agc_gain"]       = s->status.agc_gain;
  doc["gainceiling"]    = s->status.gainceiling;
  doc["bpc"]            = s->status.bpc;
  doc["wpc"]            = s->status.wpc;
  doc["raw_gma"]        = s->status.raw_gma;
  doc["lenc"]           = s->status.lenc;
  doc["hmirror"]        = s->status.hmirror;
  doc["vflip"]          = s->status.vflip;
  doc["dcw"]            = s->status.dcw;
  doc["colorbar"]       = s->status.colorbar;
  doc["xclk"]           = s->xclk_freq_hz / 1000000;  // MHz, matches CameraWebServer /status
  doc["led_intensity"]  = ledDuty;  // actual current PWM duty
  String out; serializeJson(doc, out);
  webServer.send(200, "application/json", out);
}

void initWebServer(){
  // Serve gzip-compressed dashboard (73% smaller than plain HTML)
  webServer.on("/",[](){ 
    webServer.sendHeader("Cache-Control","no-cache");
    webServer.sendHeader("Content-Encoding","gzip");
    webServer.send_P(200,"text/html",(const char*)DASHBOARD_HTML_GZ, DASHBOARD_HTML_GZ_LEN);
  });
  webServer.on("/api/status",          HTTP_GET,    apiStatus);
  webServer.on("/api/sdstats",         HTTP_GET,    apiSdStats);
  webServer.on("/api/photo",           HTTP_GET,    apiPhoto);
  webServer.on("/api/stream/start",    HTTP_GET,    apiStreamStart);
  webServer.on("/api/stream/stop",     HTTP_GET,    apiStreamStop);
  webServer.on("/api/stream/quality",  HTTP_GET,    apiStreamQuality);
  webServer.on("/api/motion",          HTTP_GET,    apiMotion);
  webServer.on("/api/timelapse",        HTTP_GET,    apiTimelapse);
  webServer.on("/api/record",          HTTP_GET,    apiRecord);
  webServer.on("/api/events",          HTTP_GET,    apiEvents);
  webServer.on("/api/download",        HTTP_GET,    apiDownload);
  webServer.on("/api/thumb",           HTTP_GET,    apiThumb);
  webServer.on("/api/delete",          HTTP_DELETE, apiDelete);
  webServer.on("/api/deleteall",       HTTP_DELETE, apiDeleteAll);
  webServer.on("/api/config",          HTTP_GET,    apiConfig);
  webServer.on("/api/config",          HTTP_POST,   apiConfig);
  webServer.on("/control",              HTTP_GET,    apiCamControl);  // CameraWebServer-compatible
  webServer.on("/camstatus",            HTTP_GET,    apiCamStatus);
  webServer.on("/xclk",                 HTTP_GET,    apiXclk);
  webServer.on("/api/restart",         HTTP_GET,    apiRestart);
  webServer.begin();
  Serial.println("[WEB] :80 ready");
}

// ============================================================
//  TELEGRAM COMMAND PROCESSOR
// ============================================================
void runTelegramRecord(int secs){
  tgSend("🎥 Starting "+String(secs)+"s "+getResLabel(streamFrameSize)+" recording...");
  if(!startAVIRecording(secs)){tgSend("? Could not start recording");return;}
  unsigned long dl=millis()+(unsigned long)(secs*1000);
  const unsigned long frameIntervalMs = 100;  // 10 fps - keeps file size manageable for Telegram upload
  while(millis()<dl){
    unsigned long frameStart = millis();
    camera_fb_t* fb=esp_camera_fb_get();
    if(fb){addAVIFrame(fb);esp_camera_fb_return(fb);}
    webServer.handleClient();
    unsigned long elapsed = millis() - frameStart;
    if (elapsed < frameIntervalMs) delay(frameIntervalMs - elapsed);
  }
  String path=finishAVIRecording();
  File vf=SD_MMC.open(path.c_str(),FILE_READ); uint32_t fsz=vf?vf.size():0; if(vf)vf.close();
  tgEnqueueVideo(path,
    "🎬 AVI Video recorded!\n"
    "📊 Stats:\n"
    "🎞 Frames: "+String(aviFrameCount)+"\n"
    "🎥 Resolution: "+String(aviWidth)+"x"+String(aviHeight)+"\n"
    "📁 Size: "+String(fsz/1024)+" KB\n"
    "⏱ Duration: "+String(secs)+"s\n"
    "💾 Saved to SD");
}


// ============================================================
//  SETUP
// ============================================================
// ============================================================
//  PENDING JOB EXECUTOR  (called from loop every iteration)
// ============================================================
void executePendingJob() {
  if (pendingJob.type == JOB_NONE) return;

  if (pendingJob.type == JOB_PHOTO) {
    pendingJob.type = JOB_NONE;  // clear before work so re-entrant calls see idle
    bool flash = pendingJob.flash;
    bool ok = captureAndSavePhoto(true, "Dashboard Button", flash);
    // Result is already sent via Telegram; /api/status reflects updated photoCount
    Serial.printf("[JOB] Photo done, ok=%d\n", (int)ok);
  }
  else if (pendingJob.type == JOB_RECORD) {
    int secs = pendingJob.recSecs;
    pendingJob.type = JOB_NONE;  // clear so motion/photo can run after record
    tgEnqueue("🎥 Starting "+String(secs)+"s "+getResLabel(streamFrameSize)+" recording...");
    if (!startAVIRecording(secs)) {
      tgEnqueue("Could not open file for recording");
      return;
    }
    unsigned long dl = millis() + (unsigned long)(secs * 1000);
    const unsigned long frameIntervalMs = 100;  // 10 fps - keeps file size manageable for Telegram upload
    while (millis() < dl) {
      unsigned long frameStart = millis();
      camera_fb_t* fb = esp_camera_fb_get();
      if (fb) { addAVIFrame(fb); esp_camera_fb_return(fb); }
      webServer.handleClient();  // keep web responsive during recording
      // Compensate for SD write + handleClient time to maintain even frame pacing
      unsigned long elapsed = millis() - frameStart;
      if (elapsed < frameIntervalMs) delay(frameIntervalMs - elapsed);
    }
    String path = finishAVIRecording();
    uint32_t fsz = 0;
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
    File vf = SD_MMC.open(path.c_str(), FILE_READ);
    fsz = vf ? vf.size() : 0; if (vf) vf.close();
    if (sdMutex) xSemaphoreGive(sdMutex);
    tgEnqueueVideo(path,
      "🎬 AVI Video recorded!\n"
      "📊 Stats:\n"
      "🎞 Frames: "+String(aviFrameCount)+"\n"
      "🎥 Resolution: "+String(aviWidth)+"x"+String(aviHeight)+"\n"
      "📁 Size: "+String(fsz/1024)+" KB\n"
      "⏱ Duration: "+String(secs)+"s\n"
      "💾 Saved to SD");
    Serial.printf("[JOB] Record done, %d frames\n", aviFrameCount);
  }
}

void setup(){
  WRITE_PERI_REG(RTC_CNTL_BROWN_OUT_REG,0);
  Serial.begin(115200); delay(1000);
  bootMs = millis();
  Serial.println("\n+======================================+");
  Serial.println("| ESP32-CAM Surveillance System v1.0  |");
  Serial.println("| Motion detection: OFF at boot        |");
  Serial.println("+======================================+");

  // Flash LED: use LEDC PWM so intensity slider works correctly.
  // ledcAttach replaces pinMode - same approach as CameraWebServer setupLedFlash().
  ledcAttach(FLASH_LED_PIN, FLASH_LEDC_FREQ, FLASH_LEDC_RES);
  ledcWrite(FLASH_LED_PIN, 0);  // start off

  preferences.begin("surveil", false);
  motionSensitivity  = preferences.getInt ("motionSens",  MOTION_SENSITIVITY_DEFAULT);
  motionCooldownS    = preferences.getInt ("motionCool",  MOTION_COOLDOWN_DEFAULT_S);
  mdThreshold        = sliderToThreshold(motionSensitivity);
  timelapseActive    = preferences.getBool("tlActive",    false);
  timelapseIntervalS = preferences.getInt ("tlInterval",  30);
  // Load credentials from NVS
  cfgWifiSSID = preferences.getString("wifiSSID", "");
  cfgWifiPass = preferences.getString("wifiPass", "");
  cfgBotToken = preferences.getString("botToken", "");
  cfgChatID   = preferences.getString("chatID",   "");
  preferences.end();  // close NVS namespace; reopen only when writing

  // Allocate motion detection buffers (grayscale only - 80x60 = 4800 bytes each)
  if(psramFound()){
    prevGray=(uint8_t*)ps_malloc(MD_PIXELS);
    currGray=(uint8_t*)ps_malloc(MD_PIXELS);
    Serial.println("[MD] PSRAM buffers OK");
  } else {
    prevGray=(uint8_t*)malloc(MD_PIXELS);
    currGray=(uint8_t*)malloc(MD_PIXELS);
    Serial.println("[MD] DRAM buffers OK");
  }
  if(!prevGray||!currGray) Serial.println("⚠ Motion buffer alloc failed");

  // Create SD mutex and Telegram queue/semaphore before any SD or WiFi use
  sdMutex  = xSemaphoreCreateMutex();
  tgBusySem = xSemaphoreCreateBinary();
  if (tgBusySem) xSemaphoreGive(tgBusySem);  // start in "not busy" state
  tgQueue  = xQueueCreate(4, sizeof(TgJob));
  if(!sdMutex || !tgQueue || !tgBusySem) Serial.println("[RTOS] Queue/Mutex/Sem alloc FAILED");

  if(!initCamera()){ Serial.println("[FATAL] Camera failed"); while(true) delay(1000); }

  if(!initSD()){
    Serial.println("⚠ No SD - media disabled");
  } else {
    SD_MMC.mkdir("/photos"); SD_MMC.mkdir("/videos");
    photoCount=countPhotos(); videoCount=countVideos();
    Serial.printf("[SD] %d photos, %d videos\n",photoCount,videoCount);
  }

  // Try STA mode if credentials exist
  if (cfgWifiSSID.length() > 0) {
    WiFi.mode(WIFI_STA);
    WiFi.begin(cfgWifiSSID.c_str(), cfgWifiPass.c_str());
    Serial.printf("[WiFi] Connecting to %s", cfgWifiSSID.c_str());
    for (int i = 0; i < 30 && WiFi.status() != WL_CONNECTED; i++) {
      delay(500); Serial.print(".");
    }
    Serial.println();
  }

  if (WiFi.status() == WL_CONNECTED) {
    apMode = false;
    Serial.println("[WiFi] Connected  IP: " + WiFi.localIP().toString());
    configTime(0, 0, NTP_SERVER);           // fetch UTC from NTP
    setenv("TZ", POSIX_TZ, 1);             // apply local timezone + DST rules
    tzset();
    delay(1500);
    // Init Telegram if credentials saved
    if (cfgBotToken.length() > 0 && cfgChatID.length() > 0) {
      telegramEnabled = true;
      securedClient.setCACert(TELEGRAM_CERTIFICATE_ROOT);
      bot = new UniversalTelegramBot(cfgBotToken.c_str(), securedClient);
      delay(2000);
      tgSend(
        "\xF0\x9F\x9A\x80 *Hellboy's WatchTower v1.0 Online!*\n\n"
        "\xF0\x9F\x93\xA1 IP: " + WiFi.localIP().toString() + "\n"
        "\xF0\x9F\x8F\xA0 Dashboard: http://" + WiFi.localIP().toString() + "\n"
        "\xF0\x9F\x93\xB6 WiFi: " + String(WiFi.RSSI()) + " dBm\n"
        "\xF0\x9F\x93\xB8 Photos on SD: " + String(photoCount) + "\n"
        "\xF0\x9F\x8E\xAC Videos on SD: " + String(videoCount) + "\n"
        "\xF0\x9F\x94\x95 Motion Detection: OFF (send /arm to enable)\n"
        "\xF0\x9F\x8E\xA5 Stream: VGA @10fps\n\n"
        "Send /help for all commands."
      );
      Serial.println("[TG] Bot ready");
      xTaskCreatePinnedToCore(
        telegramTask, "tgTask",
        16384, nullptr, 1, nullptr, 0);
      Serial.println("[RTOS] Telegram task started on Core 0");
    } else {
      Serial.println("[TG] No credentials - Telegram disabled");
      // Still start task so queue drains cleanly if credentials added later
      xTaskCreatePinnedToCore(
        telegramTask, "tgTask",
        16384, nullptr, 1, nullptr, 0);
    }
  } else {
    // No WiFi - start AP mode
    apMode = true;
    WiFi.mode(WIFI_AP);
    WiFi.softAP(AP_SSID, AP_PASS);
    delay(500);
    Serial.println("[WiFi] AP mode started");
    Serial.println("[WiFi] SSID: " AP_SSID "  Pass: " AP_PASS);
    Serial.println("[WiFi] Dashboard: http://" AP_IP_STR);
    // Start Telegram task anyway (queue must always be drained)
    xTaskCreatePinnedToCore(
      telegramTask, "tgTask",
      16384, nullptr, 1, nullptr, 0);
  }

  initWebServer();
  startStreamServer();

  Serial.println("[SYS] All systems GO");
  if (apMode) {
    Serial.println("[SYS] Mode: ACCESS POINT  SSID: " AP_SSID);
    Serial.println("[SYS] Dashboard -> http://" AP_IP_STR);
  } else {
    Serial.printf("[SYS] Mode: STA  IP: %s\n", WiFi.localIP().toString().c_str());
    Serial.printf("[SYS] Dashboard -> http://%s\n", WiFi.localIP().toString().c_str());
  }
  Serial.printf("[MD]  Threshold=%.2f  Cooldown=%ds  Warmup=%d frames\n",
    mdThreshold, motionCooldownS, MD_WARMUP_FRAMES);
}

// ============================================================
//  MAIN LOOP
// ============================================================
void loop(){
  webServer.handleClient();
  executePendingJob();  // run any queued photo/record job

  // WiFi reconnection watchdog (STA mode only)
  // If the router reboots or signal drops, attempt reconnect every 30 seconds.
  if (!apMode && WiFi.status() != WL_CONNECTED) {
    static unsigned long lastReconnectMs = 0;
    unsigned long now = millis();
    if (now - lastReconnectMs >= 30000) {
      lastReconnectMs = now;
      Serial.println("[WiFi] Connection lost - attempting reconnect...");
      WiFi.disconnect();
      WiFi.begin(cfgWifiSSID.c_str(), cfgWifiPass.c_str());
      // Wait up to 10 s for reconnect without blocking motion/web entirely
      for (int i = 0; i < 20 && WiFi.status() != WL_CONNECTED; i++) {
        delay(500);
        webServer.handleClient();
      }
      if (WiFi.status() == WL_CONNECTED) {
        Serial.println("[WiFi] Reconnected  IP: " + WiFi.localIP().toString());
        // Re-sync NTP after reconnect
        configTime(0, 0, NTP_SERVER);
        setenv("TZ", POSIX_TZ, 1);
        tzset();
        tgSend("WiFi reconnected. IP: " + WiFi.localIP().toString());
      } else {
        Serial.println("[WiFi] Reconnect failed - will retry in 30s");
      }
    }
  }

  // Motion detection block
  // Skipped entirely when: disarmed, recording, or within cooldown window
  if(motionArmed && !aviRecording){
    unsigned long now=millis();
    unsigned long coolMs=(unsigned long)(motionCooldownS*1000);

    if(now - lastMotionMs > coolMs){
      camera_fb_t* fb=esp_camera_fb_get();
      if(fb){
        bool motion=checkMotion(fb);
        esp_camera_fb_return(fb);

        if(motion){
          lastMotionMs=now;
          Serial.println("🏃 *** CONFIRMED ***");

          // Brief flash to illuminate scene
          ledcWrite(FLASH_LED_PIN, 255); delay(80); ledcWrite(FLASH_LED_PIN, ledDuty);

          // captureAndSavePhoto sends the photo WITH the caption - no second message needed
          captureAndSavePhoto(true,"Motion Detection",false);
        }
      }
    }
  }

  // Timelapse block
  // Skipped when: inactive, recording, or a job is already pending.
  if (timelapseActive && !aviRecording && pendingJob.type == JOB_NONE) {
    unsigned long now = millis();
    unsigned long tlMs = (unsigned long)(timelapseIntervalS * 1000UL);
    if (now - lastTimelapseMs >= tlMs) {
      lastTimelapseMs = now;
      Serial.printf("[TL] Capturing timelapse frame #%d\n", photoCount + 1);
      captureAndSavePhoto(false, "Timelapse", false);
    }
  }

  // OPT: Dynamic end-of-loop yield.
  // - Skip the delay entirely when a job is queued (execute it immediately next iteration).
  // - Use vTaskDelay() instead of delay() so FreeRTOS can schedule other tasks
  //   (telegramTask, IDLE0 watchdog) during the yield rather than busy-waiting.
  // - When motion is armed and inside the cooldown window, yield only 10ms so
  //   we can process webServer clients quickly without wasting time on a fixed 30ms stall.
  if (pendingJob.type != JOB_NONE) {
    // Work is waiting - don't delay at all, fall through to next loop() immediately
  } else if (motionArmed && !aviRecording) {
    vTaskDelay(pdMS_TO_TICKS(10));  // armed: stay responsive, ~100Hz check rate
  } else {
    vTaskDelay(pdMS_TO_TICKS(30));  // idle: ~33Hz, yields to WiFi + TG task
  }
}

/*
 * ===============================================================
 *  QUICK SETUP GUIDE  v1.0
 * ===============================================================
 *
 *  1. LIBRARIES  (Sketch > Include Library > Manage Libraries)
 *       "Universal Arduino Telegram Bot"  by Brian Lough
 *       "ArduinoJson"  v6.x  by Benoit Blanchon
 *
 *  2. BOARD MANAGER URL:
 *       https://raw.githubusercontent.com/espressif/arduino-esp32/
 *       gh-pages/package_esp32_index.json
 *       Board            : AI Thinker ESP32-CAM (HW-381 + OV2640)
 *       Partition Scheme : Huge APP (3MB No OTA / 1MB SPIFFS)
 *       CPU Frequency    : 240 MHz
 *
 *  3. FILL IN at top of file:
 *       WIFI_SSID / WIFI_PASS
 *       BOT_TOKEN  (@BotFather on Telegram ? /newbot)
 *       CHAT_ID    (@userinfobot on Telegram)
 *
 *  4. KEY ARCHITECTURE NOTES (v1.0):
 *       + WebServer retained - no library compatibility issues.
 *       + Telegram FreeRTOS task pinned Core 0. tgSend() non-blocking.
 *       + sdMutex guards all SD_MMC calls across both cores.
 *       + Pending-job state machine: apiPhoto/apiRecord return
 *         instantly; executePendingJob() runs the work in loop().
 *         webServer.handleClient() is called during recording so
 *         the dashboard stays responsive even during a 30s video.
 *       + Dashboard gzip: 31 KB -> 8.5 KB PROGMEM (73% smaller).
 *       + Resolution changes always use full camera deinit+reinit.
 *       + CAMERA_GRAB_LATEST with 2 PSRAM buffers prevents overflow.
 *       + AVI dimensions auto-detected from first-frame JPEG SOF.
 *
 *  5. TUNING MOTION SENSITIVITY:
 *       Open Serial Monitor (115200 baud) and watch "[MD] MAD=x.xx"
 *       Idle scene: MAD should be 0.5-3.0
 *       Motion in frame: MAD spikes to 10+
 *       Set MD_THRESHOLD_DEFAULT just above your idle noise value
 *
 *  6. MOTION IS OFF BY DEFAULT
 *       Enable via dashboard "Enable Motion" or /arm in Telegram
 *
 *  7. FILENAMES  (on SD card):
 *       Photos : /photos/YYYY-MM-DD_HH-MM-SS.jpg
 *       Videos : /videos/YYYY-MM-DD_HH-MM-SS_<RES>_<DUR>s.avi
 *       If NTP not synced: notime_<millis>.jpg / .avi
 * ===============================================================
 */
