/*
 * +==========================================================================+
 * |            ESP32-CAM Hellboy's WatchTower Surveillance Dashboard         |
 * |            Hardware : AI Thinker ESP32-CAM  |  OV2640  |  HW-381 MB      |
 * |            Version  : 1.0.0                                              |
 * +==========================================================================+
 * |  REQUIRED LIBRARIES (Arduino IDE -> Manage Libraries):                   |
 * |    - "Universal Arduino Telegram Bot"  by Brian Lough                    |
 * |    - "ArduinoJson"                     by Benoit Blanchon  (v6.x)        |
 * |                                                                          |
 * |  BOARD SETTINGS:                                                         |
 * |    Board            : AI Thinker ESP32-CAM                               |
 * |    Partition Scheme : Huge APP (3MB No OTA / 1MB SPIFFS)                 |
 * |    CPU Frequency    : 240 MHz                                            |
 * |    Upload Speed     : 115200                                             |
 * +==========================================================================+
 */

// ============================================================
//  USER CONFIGURATION -- Fill in before flashing
// ============================================================
// WiFi + Telegram credentials loaded from Preferences (NVS) at boot.
// Configure via dashboard Settings panel. No hardcoded credentials.
#define AP_SSID     "ESP32HBWT"
#define AP_PASS     "watchtower"
#define AP_IP_STR   "192.168.4.1"

// Motion Detection - THESE ARE THE TUNED DEFAULTS
// mdThreshold: mean absolute difference of grayscale values (0-255)
//   lower  = more sensitive (fires easier)
//   higher = less sensitive (only fires on big movement)
//   Good range: 4.0 (very sensitive) to 20.0 (only large motion)
#define MD_THRESHOLD_DEFAULT    8.0f   // MAD trigger level
#define MOTION_SENSITIVITY_DEFAULT  50  // 1-100 slider position for above
#define MOTION_COOLDOWN_DEFAULT_S    8  // seconds between repeated alerts
#define MD_WARMUP_FRAMES           20  // frames to discard at startup / arm

#define NTP_SERVER          "pool.ntp.org"
// POSIX TZ string handles DST transitions automatically.
// Change this to match your timezone. Examples:
//   Central European : "CET-1CEST,M3.5.0,M10.5.0/3"
//   UK               : "GMT0BST,M3.5.0/1,M10.5.0"
//   US Eastern       : "EST5EDT,M3.2.0,M11.1.0"
//   US Pacific       : "PST8PDT,M3.2.0,M11.1.0"
#define POSIX_TZ            "CET-1CEST,M3.5.0,M10.5.0/3"

// -- Camera quality tuning -------------------------------------
// JPEG quality: lower number = higher quality / larger file
//   Stream: 12 keeps frames small for smooth WiFi delivery
//   Photo:  8 gives good detail without exhausting PSRAM
// Photo resolution: SVGA (800x600) is reliable on this hardware.
// UXGA (1600x1200) often produces blank frames due to PSRAM limits.
#define STREAM_JPEG_QUALITY   12
#define PHOTO_JPEG_QUALITY     6
#define PHOTO_FRAMESIZE        FRAMESIZE_XGA    // 1024x768 - good quality still
// ============================================================

#include "esp_camera.h"
#include "img_converters.h"
#include "Arduino.h"
#include "soc/soc.h"
#include "soc/rtc_cntl_reg.h"
#include "driver/rtc_io.h"
#include <WiFi.h>
#include <WiFiClientSecure.h>
#include <WebServer.h>
#include <SD_MMC.h>
#include <FS.h>
#include <Preferences.h>
#include <time.h>
#include <esp_http_server.h>
#include <UniversalTelegramBot.h>
#include <ArduinoJson.h>
#include <vector>
#include <algorithm>

// ============================================================
//  AI THINKER PIN MAP
// ============================================================
#define PWDN_GPIO_NUM   32
#define RESET_GPIO_NUM  -1
#define XCLK_GPIO_NUM    0
#define SIOD_GPIO_NUM   26
#define SIOC_GPIO_NUM   27
#define Y9_GPIO_NUM     35
#define Y8_GPIO_NUM     34
#define Y7_GPIO_NUM     39
#define Y6_GPIO_NUM     36
#define Y5_GPIO_NUM     21
#define Y4_GPIO_NUM     19
#define Y3_GPIO_NUM     18
#define Y2_GPIO_NUM      5
#define VSYNC_GPIO_NUM  25
#define HREF_GPIO_NUM   23
#define PCLK_GPIO_NUM   22
#define FLASH_LED_PIN    4
// LEDC channel for flash LED PWM - must not conflict with camera LEDC_CHANNEL_0
// Camera uses LEDC_CHANNEL_0 for XCLK. We use channel 1 for the flash LED.
#define FLASH_LEDC_CHANNEL  1
#define FLASH_LEDC_FREQ     5000   // 5 kHz - same as CameraWebServer
#define FLASH_LEDC_RES      8      // 8-bit = 0-255
static int ledDuty = 0;  // current LED PWM duty (0=off, 255=full)

// ============================================================
//  MOTION DETECTION BUFFERS
//  JPG_SCALE_8X: VGA 640x480  ?  80x60 grayscale = 4800 bytes
//  Using 8x scale (not 4x) makes the diff faster and less noisy
// ============================================================
#define MD_W       80
#define MD_H       60
#define MD_PIXELS  (MD_W * MD_H)     // 4800

// Each buffer holds one grayscale frame (1 byte per pixel)
static uint8_t* prevGray       = nullptr;
static uint8_t* currGray       = nullptr;
static bool     prevFrameReady = false;

// Warm-up counter - discard first N frames after arming
static int  mdWarmupCount  = 0;
static bool mdWarmedUp     = false;

// Consecutive-hit counter - require 2 hits before firing
static int  mdConsecutive  = 0;
#define MD_CONSEC_REQUIRED  2

// Actual float threshold derived from slider
static float mdThreshold = MD_THRESHOLD_DEFAULT;

// ============================================================
//  AVI WRITER
// ============================================================
#define AVI_MAX_FRAMES 3000
static File     aviFile;
// Note: idx1 index chunk is not written (dwFlags=0x00 in avih).
// The offset/size arrays were previously allocated but never used.
// 24 KB of PSRAM freed back to camera buffers and WiFi stack.
static int      aviFrameCount   = 0;
static unsigned long aviStartMs = 0;
static bool     aviRecording    = false;
static char     aviFilePath[96] = "";
static uint32_t aviMoviOffset   = 0;
// Actual pixel dimensions extracted from first frame's JPEG header
static int      aviWidth        = 640;
static int      aviHeight       = 480;

// ============================================================
//  GLOBAL STATE
// ============================================================
volatile bool  streamActive      = false;
bool  motionArmed       = false;   // ? OFF by default (v2.2 fix)
bool  telegramEnabled   = false;  // enabled once credentials loaded from NVS
bool  emailEnabled      = false;  // reserved for future email alert feature
// Runtime credentials - loaded from Preferences in setup()
static String cfgWifiSSID  = "";
static String cfgWifiPass  = "";
static String cfgBotToken  = "";
static String cfgChatID    = "";
static bool   apMode       = false;  // true when running as AP (no router)

int   motionSensitivity = MOTION_SENSITIVITY_DEFAULT;
int   motionCooldownS   = MOTION_COOLDOWN_DEFAULT_S;

unsigned long lastMotionMs   = 0;
unsigned long lastTelegramMs = 0;
unsigned long bootMs         = 0;   // set in setup() for uptime tracking

// ── Timelapse ──────────────────────────────────────────────────
bool          timelapseActive    = false;
int           timelapseIntervalS = 30;   // seconds between captures
unsigned long lastTimelapseMs    = 0;

int photoCount = 0;
int videoCount = 0;

// OPT: Events list cache - avoids full SD directory scan on every /api/events call.
// Set dirty whenever photoCount or videoCount changes (capture, delete, deleteAll).
static bool   eventsCacheDirty = true;   // force scan on first request
static int    eventsCachePhotoSnap = -1; // photoCount snapshot at last scan
static int    eventsCacheVideoSnap = -1; // videoCount snapshot at last scan

// Stream quality settings (changeable from dashboard)
// framesize_t values: FRAMESIZE_QVGA=5, VGA=8, SVGA=9, XGA=10, SXGA=12, UXGA=13
int  streamFrameSize = FRAMESIZE_VGA;   // default VGA
int  streamFps       = 10;              // default 10 fps

// Events pagination - limit displayed to avoid memory exhaustion
#define EVENTS_PAGE_SIZE  20

httpd_handle_t      streamHttpd = NULL;
Preferences         preferences;
WebServer           webServer(80);
WiFiClientSecure    securedClient;
UniversalTelegramBot* bot = nullptr;

// -- Telegram background task -----------------------------------
// All Telegram I/O runs on Core 0. loop() on Core 1 never blocks.
typedef enum { TG_TEXT, TG_PHOTO, TG_VIDEO } TgJobType;
// OPT: union payload - path/caption and text are mutually exclusive by job type.
// Saves ~640 bytes per queue slot = ~3.5KB total queue SRAM vs the old flat struct.
struct TgJob {
  TgJobType type;
  union {
    struct {
      char path[128];    // SD path (PHOTO/VIDEO jobs)
      char caption[384]; // caption (PHOTO/VIDEO jobs) - was 512, trimmed to fit union
    };
    char text[512];      // body (TG_TEXT jobs)
  };
};
static QueueHandle_t     tgQueue    = nullptr;  // created in setup()
static SemaphoreHandle_t sdMutex    = nullptr;  // guards all SD_MMC calls
static SemaphoreHandle_t tgBusySem  = nullptr;  // binary sem: taken while TLS send in progress
// tgBusySem serialises all TLS operations within telegramTask.
// Only one mbedTLS session runs at a time - two simultaneous sessions
// exhaust heap and cause silent failures.

// -- Pending-job state machine (Item 5) -------------------------
// HTTP handlers are called from webServer.handleClient() on the main
// task. Heavy work (photo/record) sets a pending flag and returns
// immediately so handleClient() never blocks for 2-30 seconds.
// loop() checks and executes pending jobs each iteration.
typedef enum { JOB_NONE, JOB_PHOTO, JOB_RECORD } PendingJobType;
struct PendingJob {
  PendingJobType type     = JOB_NONE;
  bool           flash    = false;
  int            recSecs  = 10;
};
static volatile PendingJob pendingJob;


// ============================================================
//  FORWARD DECLARATIONS
// ============================================================
void   tgEnqueue(const String& msg);
void   tgEnqueuePhoto(const String& path, const String& cap);
void   tgEnqueueVideo(const String& path, const String& cap);
void   tgSend(const String& msg);
void   executePendingJob();
void   sendPhotoToTelegram(const String& filePath, const String& caption);
void   sendVideoToTelegram(const String& filePath, const String& caption);
bool   captureAndSavePhoto(bool sendTg, String triggerLabel, bool useFlash);
bool   startAVIRecording(int durationSec);
bool   addAVIFrame(camera_fb_t* fb);
String finishAVIRecording();
bool   checkMotion(camera_fb_t* fb);
int    countPhotos();
int    countVideos();
String getTimestamp();
String getUptime();
void   runTelegramRecord(int secs);
void   armMotion();
void   disarmMotion();
void   applyStreamResolution();
void   deleteAllSD();
// Convert slider 1-100 -> float threshold (inverse: high slider = low threshold)
inline float sliderToThreshold(int s) {
  // slider 1   -> ~13.88  (least sensitive, barely triggers)
  // slider 50  ->   8.0   (default, matches MD_THRESHOLD_DEFAULT)
  // slider 100 ->   2.0   (most sensitive)
  return 14.0f - (s * 12.0f / 100.0f);
}

// ============================================================
//  EMBEDDED WEB DASHBOARD - gzip-compressed (73% smaller)
// ============================================================
// Dashboard HTML gzip-compressed: 11285 bytes (was 31292 bytes plain)
static const uint16_t DASHBOARD_HTML_GZ_LEN = 13044;
static const uint8_t  DASHBOARD_HTML_GZ[] PROGMEM = {
  0x1f,0x8b,0x08,0x00,0x12,0x65,0xbb,0x69,0x02,0xff,0xdd,0x7d,0x6b,0x6f,0x1b,0x49,
  0xb6,0xd8,0x77,0xfd,0x8a,0x1a,0x0e,0xee,0x90,0x5c,0x8b,0x14,0x5f,0x7a,0x91,0x92,
  0x1c,0xbd,0x2c,0x6b,0x56,0x92,0x35,0x96,0x6c,0xcf,0xd8,0x3b,0x30,0x9a,0xec,0x22,
  0xd9,0x76,0x93,0xcd,0xe9,0x6e,0x4a,0xa2,0x75,0x1d,0x2c,0x90,0x07,0x92,0xe0,0xe2,
  0x4e,0x92,0xbb,0x37,0x41,0x16,0x09,0x76,0xf7,0x43,0x90,0x2f,0xf7,0x43,0x16,0x01,
  0x2e,0x76,0x11,0x20,0x1f,0xf2,0x53,0xe6,0x0f,0x64,0x7f,0x42,0xce,0x39,0x55,0xd5,
  0x5d,0xd5,0xdd,0x7c,0xc8,0xf6,0xcc,0xf5,0x78,0x1e,0x36,0xbb,0xbb,0xea,0x54,0xd5,
  0x39,0xa7,0xce,0xab,0xaa,0x4e,0x6d,0x7d,0x76,0xf0,0x68,0xff,0xf2,0x9b,0xf3,0x43,
  0xd6,0x0f,0x07,0xee,0xce,0xd2,0x16,0xfe,0xc5,0x5c,0x6b,0xd8,0xdb,0xce,0xf1,0x61,
  0x0e,0x5f,0x70,0xcb,0x86,0xbf,0x06,0x3c,0xb4,0x58,0xa7,0x6f,0xf9,0x01,0x0f,0xb7,
  0x73,0x4f,0x2e,0x1f,0x94,0x36,0x72,0xea,0xf5,0xd0,0x1a,0xf0,0xed,0xdc,0x95,0xc3,
  0xaf,0x47,0x9e,0x1f,0xe6,0x58,0xc7,0x1b,0x86,0x7c,0x08,0xc5,0xae,0x1d,0x3b,0xec,
  0x6f,0xdb,0xfc,0xca,0xe9,0xf0,0x12,0x3d,0x2c,0x3b,0x43,0x27,0x74,0x2c,0xb7,0x14,
  0x74,0x2c,0x97,0x6f,0x57,0x11,0x86,0xeb,0x0c,0x5f,0x33,0x9f,0xbb,0xdb,0x39,0x07,
  0x6a,0xe6,0x58,0x38,0x19,0x01,0x38,0x67,0x60,0xf5,0xf8,0x4a,0x70,0xd5,0xbb,0x77,
  0x33,0x70,0x73,0xac,0xef,0xf3,0xee,0x76,0xce,0xb6,0x42,0xab,0x69,0x7c,0x69,0xb5,
  0xad,0x80,0xaf,0x35,0x96,0xcf,0x1f,0x9e,0xd5,0x9e,0x4f,0xf6,0x1a,0xed,0x67,0x37,
  0xe3,0xce,0x9b,0x8a,0x63,0x3d,0x7c,0x5c,0xe9,0x1c,0x78,0x57,0x27,0x75,0xbb,0x6e,
  0x4f,0x56,0xeb,0xa7,0x93,0xd5,0xab,0xce,0xa0,0x73,0x75,0xfa,0x6a,0xf7,0xfa,0x74,
  0x7f,0xf3,0x8d,0x3d,0xe8,0x38,0xc7,0x0f,0x9f,0x8f,0x9e,0x7f,0x6d,0xef,0xb7,0xeb,
  0xbd,0xcd,0xe3,0x57,0xbb,0xbd,0xd3,0xfd,0xdd,0x37,0xa7,0x0e,0xfe,0x7f,0x7c,0xef,
  0xfc,0xe1,0x97,0xee,0x37,0xf5,0xaf,0x7a,0x76,0xcd,0x7d,0x6d,0x1f,0xe1,0xf7,0xd3,
  0xc9,0xb1,0xb3,0xe7,0x3d,0x7f,0xe6,0x0e,0xad,0x87,0x5f,0xa9,0xe7,0x09,0x3f,0xa8,
  0x38,0x67,0xce,0x71,0xef,0xf9,0xc0,0x0d,0xda,0xf0,0xfb,0xf8,0xcd,0x61,0xed,0xf4,
  0xd9,0xf1,0x04,0x60,0x5c,0x9d,0xbf,0xba,0x99,0x3c,0x7f,0x76,0x56,0x39,0x7e,0x88,
  0xf5,0xbf,0x82,0xf6,0x5e,0xc3,0xdf,0x87,0xd7,0x50,0xaf,0x6e,0x3d,0x7b,0x5c,0xb1,
  0xa0,0xfc,0x29,0xbe,0x3f,0xea,0xbb,0xd6,0x33,0xdb,0xb3,0xf1,0xf9,0x12,0xfb,0xf5,
  0x65,0xe3,0xfc,0xe2,0xf8,0x0d,0x94,0x1b,0x58,0xcf,0x6e,0x02,0xf8,0xfd,0xea,0xec,
  0xb2,0xdf,0x3f,0x1b,0x3c,0x1f,0x1c,0x3b,0x1b,0xf7,0xce,0x8f,0xce,0x46,0x9d,0xc1,
  0x59,0xf0,0xfc,0x62,0xef,0x15,0xa7,0x3a,0xdf,0x00,0x8c,0xb3,0x55,0x28,0x77,0xf3,
  0x68,0xff,0xb8,0xd7,0x79,0x05,0x7d,0xba,0x68,0x54,0xf5,0xfa,0xa7,0x47,0x5f,0xdd,
  0x9c,0x5e,0x1e,0xd6,0x17,0xad,0x7f,0x3a,0x49,0xd4,0xaf,0x3d,0x77,0x1e,0x5d,0x3e,
  0xb9,0xa6,0xfa,0x12,0x37,0xa2,0xee,0xa1,0x1c,0x17,0xf6,0xdb,0x1e,0x3d,0x7f,0xf8,
  0xd8,0x83,0xf2,0x35,0x13,0x57,0x5f,0xa9,0x31,0xdd,0x9c,0xbc,0x7a,0x02,0x6d,0x3d,
  0x1f,0xb5,0x8f,0xae,0x37,0x8f,0x9d,0xd3,0xea,0xa3,0xa3,0xc3,0xda,0xf3,0xc1,0x37,
  0xce,0xc9,0x9b,0xc6,0xc6,0x37,0x35,0x77,0xf2,0x4d,0xed,0xc6,0x85,0xbe,0x60,0xd9,
  0xc9,0xd9,0xc5,0x71,0xef,0x9b,0x3a,0xe1,0x0c,0x71,0x31,0x49,0xd7,0x3f,0x1b,0x9c,
  0x1e,0x7d,0x03,0xf5,0x4f,0xa9,0xfe,0x49,0x1d,0x78,0xe0,0x4d,0x63,0x1b,0x99,0x2a,
  0x74,0x42,0x97,0xef,0x3c,0xe4,0xae,0xdb,0xf6,0x26,0xf9,0x80,0x3d,0xb3,0xc2,0x4e,
  0xff,0xd2,0xbb,0xe6,0x3e,0xbb,0xaa,0x96,0x2b,0x5b,0x2b,0xa2,0xc0,0xd2,0x56,0x10,
  0x4e,0xf0,0x6f,0xc6,0x7e,0x71,0xdb,0xf6,0x6e,0x4a,0x81,0xf3,0xc6,0x19,0xf6,0x9a,
  0x6d,0xcf,0xb7,0xb9,0x5f,0x82,0x37,0xad,0x81,0xe5,0xf7,0x9c,0x61,0xb3,0xd2,0x1a,
  0x59,0xb6,0x8d,0xdf,0x2a,0x6f,0xa1,0x74,0xdb,0xb3,0x27,0xb7,0x5d,0x60,0xf4,0x52,
  0xd7,0x1a,0x38,0xee,0xa4,0x99,0xbf,0xe0,0x3d,0x8f,0xb3,0x27,0xc7,0xf9,0xe5,0x60,
  0x12,0x84,0x7c,0x50,0x1a,0x3b,0xcb,0x81,0x35,0x0c,0x4a,0x01,0xf7,0x9d,0x2e,0xf0,
  0x69,0xe7,0x75,0xcf,0xf7,0xc6,0x43,0xbb,0xf9,0x79,0xc5,0xae,0x56,0xab,0xeb,0xad,
  0x8e,0xe7,0x7a,0x7e,0xf3,0xf3,0xce,0xa6,0x5d,0xb5,0x37,0x5b,0x03,0x67,0x58,0xea,
  0x73,0xa7,0xd7,0x0f,0x9b,0xd5,0x4a,0xe5,0xaa,0x8f,0xad,0xe0,0xe4,0xe3,0xfe,0xad,
  0xed,0x04,0x23,0xd7,0x9a,0x34,0xbb,0x2e,0xbf,0x69,0x59,0xae,0xd3,0x1b,0x96,0x1c,
  0x68,0x21,0x68,0x76,0x60,0x9a,0x71,0xbf,0xf5,0x6a,0x1c,0x84,0x4e,0x77,0x52,0x92,
  0x13,0xaf,0x19,0x8c,0x2c,0x98,0x70,0x6d,0x1e,0x5e,0x73,0x3e,0x6c,0x01,0x1c,0xe8,
  0xaf,0xd6,0x7c,0x75,0xad,0xda,0xae,0xd5,0x5a,0xd1,0x18,0xc3,0xd0,0x1b,0x34,0xab,
  0xa3,0x1b,0x16,0x78,0xae,0x63,0xb3,0xcf,0xeb,0x95,0xfa,0x5a,0xdd,0x8e,0xc6,0x5b,
  0xad,0xc0,0xa7,0x1a,0xfc,0xd1,0xc2,0xf6,0x4b,0xd7,0xbe,0x35,0x6a,0xe2,0x1f,0xad,
  0x1e,0xfc,0x58,0x83,0xd7,0x23,0x2f,0x80,0x49,0xed,0x0d,0x9b,0xd0,0x8b,0xce,0xeb,
  0x49,0x2b,0xf4,0x46,0x80,0xae,0x37,0x25,0x67,0x68,0xf3,0x1b,0x1c,0x0c,0x0e,0xa5,
  0xec,0x7a,0x3d,0x6f,0xee,0x48,0x10,0x64,0x95,0x9a,0x42,0xd4,0x02,0x31,0x78,0xb3,
  0x5a,0xae,0xae,0xfa,0x7c,0x20,0xde,0x5c,0x0b,0x04,0xad,0x55,0x2a,0x0a,0x7b,0x7c,
  0x8d,0xdb,0xdd,0x7a,0xd4,0x02,0xeb,0x57,0x6f,0xf5,0xba,0x35,0xac,0xea,0xf2,0x10,
  0x80,0x97,0x10,0x2d,0x38,0xa0,0x72,0xa5,0xce,0x07,0x54,0xe3,0xda,0xe9,0x3a,0x25,
  0xdb,0x0b,0x6f,0x49,0x38,0x89,0x96,0x23,0x1a,0xc0,0x6f,0x89,0x22,0xdf,0xb2,0x9d,
  0x71,0xd0,0x5c,0xad,0xfc,0x55,0x1a,0x99,0xf5,0x6e,0x7b,0x73,0xb5,0xd2,0x22,0xde,
  0xe9,0x5b,0xb6,0x77,0xdd,0xac,0xb0,0x0a,0xdb,0x00,0x94,0xa9,0x4f,0x84,0xb5,0xa0,
  0xef,0x83,0x98,0x13,0xbc,0x13,0x35,0x5b,0xf6,0xba,0xdd,0x5b,0x1d,0x58,0x77,0x63,
  0xb5,0xda,0xd8,0xcc,0x04,0x26,0x3e,0x61,0xf5,0xa1,0x75,0x65,0xe2,0x51,0xd1,0x21,
  0x41,0x9e,0x34,0x7a,0xa9,0xf1,0xd0,0x6a,0xeb,0x6d,0x0e,0xbd,0x21,0x97,0xe3,0xcc,
  0xe0,0x01,0x89,0xe4,0x8d,0xf6,0x66,0x63,0x93,0x8b,0xc1,0x2b,0xb6,0x58,0x85,0xc2,
  0xd5,0x7a,0x0a,0x49,0xd8,0x91,0xce,0xd8,0x0f,0xa0,0xda,0xc8,0x73,0x88,0xa8,0x31,
  0x3d,0xca,0x1b,0x44,0x8f,0xd0,0x87,0x79,0x21,0x58,0x06,0x88,0x1b,0xa8,0x6e,0x95,
  0xad,0x4e,0xe8,0x5c,0xf1,0x65,0xfc,0xdd,0xec,0x7b,0x57,0xc0,0xf9,0x3a,0x72,0x6a,
  0xd5,0xda,0x5a,0xcd,0x4e,0xcc,0x1a,0xd9,0xb8,0x7c,0xb9,0xba,0x61,0xad,0x75,0xbb,
  0x08,0x6f,0xe5,0x17,0xd8,0xd9,0x5f,0xb0,0x13,0x6b,0xe2,0x8d,0xc3,0x26,0x73,0x79,
  0x37,0x04,0xc5,0xe4,0x8e,0x07,0x43,0xe6,0x04,0x2c,0x67,0x8d,0x43,0x2f,0x07,0x83,
  0x65,0x4e,0xc8,0x04,0x6d,0x02,0x16,0x7a,0xac,0x0b,0x8f,0x4e,0x18,0x28,0x15,0x26,
  0x60,0x14,0xc2,0x3e,0x67,0x41,0xe8,0x73,0x6b,0xc0,0x3a,0x96,0x6f,0x17,0xcb,0xec,
  0xd2,0x7c,0x83,0x20,0x05,0x0b,0x01,0x00,0x35,0x0d,0x05,0x74,0x01,0xa2,0x3f,0xee,
  0x01,0xfc,0xb8,0x12,0xe9,0x30,0xc6,0x6f,0x60,0xc4,0xee,0xa4,0xcc,0x76,0xc5,0x47,
  0xf1,0x16,0xc6,0x7b,0x1d,0xb0,0xc2,0xc5,0xd3,0xa3,0xdd,0x65,0xf6,0xf5,0xd1,0x6e,
  0xb9,0x5c,0x2e,0x0a,0x28,0x58,0x86,0x9a,0xa3,0x22,0xcb,0xf4,0xac,0x0f,0x4c,0xbe,
  0xb6,0x86,0x36,0x7d,0xba,0xee,0x7b,0x2e,0x07,0x7a,0x01,0x4c,0xe8,0x1c,0x1f,0x06,
  0x65,0x01,0xe6,0x31,0x32,0xb8,0xaa,0x13,0x84,0xd6,0x24,0x60,0x16,0x8c,0xfc,0x86,
  0xdb,0xac,0x8e,0xf3,0x1c,0x94,0x71,0x0f,0x5a,0x71,0x79,0xa0,0x6a,0x24,0x05,0x8c,
  0x60,0x27,0xf6,0x9a,0xf3,0x51,0xa0,0x35,0xd5,0xf3,0x81,0x75,0xc4,0x37,0x80,0xe5,
  0x0c,0xe9,0x93,0xb2,0x0b,0x24,0xa8,0x47,0x43,0x36,0xf0,0xda,0x0e,0x94,0xbe,0xe6,
  0x0c,0x69,0x0c,0x75,0x38,0xcd,0x28,0xc4,0x7f,0xb5,0xeb,0x23,0xda,0x38,0xbc,0x9f,
  0x84,0x7d,0x60,0x33,0xe8,0x97,0xeb,0x4a,0xd4,0x75,0x7c,0x10,0x67,0x02,0xcc,0x0a,
  0xb2,0x0c,0xf6,0xc6,0x72,0x86,0x9a,0x80,0xc4,0x0e,0xb4,0xf0,0x8f,0x12,0x70,0x3d,
  0xbc,0x09,0x79,0x49,0x0c,0x33,0x68,0x22,0xc1,0xc5,0xf0,0x84,0x90,0x69,0xc0,0x0f,
  0x83,0x9f,0xe9,0x8d,0x14,0xf6,0x58,0xd8,0x98,0x3f,0x80,0x25,0x3f,0x6c,0x65,0xa3,
  0x41,0xb0,0x1b,0x3b,0xd1,0x08,0x81,0x44,0x6a,0x4a,0xbe,0xc2,0x61,0x29,0x56,0x91,
  0x8c,0x41,0xac,0x22,0x06,0xf1,0xb9,0xf8,0xb4,0x0f,0x15,0x6e,0x53,0x1c,0x44,0x3a,
  0x41,0xbc,0x5d,0x6b,0x40,0xcf,0x65,0x4b,0x11,0x0a,0xa1,0x09,0xe8,0x39,0xa0,0x52,
  0x34,0xbb,0xcc,0xba,0x63,0xd7,0xd5,0xa1,0xff,0xb3,0x01,0xb7,0x1d,0xab,0x30,0xb0,
  0x6e,0x24,0x98,0x8d,0x35,0x00,0x53,0xbc,0xa5,0x81,0x6b,0xf8,0xcb,0x46,0x19,0x10,
  0x23,0xad,0x5a,0xa0,0xbb,0xa0,0x49,0xdf,0x12,0x84,0x17,0x8e,0xbd,0x9d,0x83,0xc9,
  0x5a,0x72,0x61,0xda,0xe6,0xbe,0xd5,0x20,0xb2,0x1d,0x66,0x3b,0x57,0x30,0x16,0x3f,
  0x80,0xd1,0xf4,0x1d,0xd7,0x86,0x8f,0xf1,0x18,0x41,0x27,0xfc,0x95,0x36,0xb8,0x8a,
  0x00,0x97,0xc6,0x45,0x76,0x39,0xa9,0x15,0x15,0xe1,0x50,0x3c,0x56,0x6b,0x02,0x3b,
  0x4a,0xcf,0x68,0x22,0x67,0xd3,0x17,0xc2,0x5e,0x08,0x4e,0x0d,0x6e,0x72,0x68,0x42,
  0x4e,0x23,0xa1,0x25,0x24,0x94,0x94,0x1a,0xa0,0xf5,0x35,0x94,0x5d,0xaa,0xd5,0x06,
  0xb6,0x2a,0x69,0x42,0x02,0x8c,0x86,0x37,0x55,0xcd,0x66,0xc8,0x56,0x53,0x6e,0xe2,
  0x08,0x5a,0x19,0xbc,0xa8,0xf4,0x73,0x25,0x6a,0xa4,0x04,0xfc,0x7b,0x6b,0x7e,0xc4,
  0xf2,0xd1,0x77,0xd6,0xaf,0x19,0xdd,0xde,0xc0,0x6e,0x9b,0x82,0x3c,0x51,0xbb,0xaa,
  0xe6,0x42,0xc8,0x6f,0xc2,0x12,0x49,0xe7,0xae,0xe7,0x0f,0x9a,0xe3,0xd1,0x88,0xfb,
  0x1d,0x30,0xb0,0xd3,0x1a,0x74,0x1d,0x91,0x2a,0xd8,0xf1,0x87,0xdf,0xfc,0x1a,0xfe,
  0x63,0x17,0x82,0xc7,0xe5,0x13,0xb1,0x9f,0x12,0xc2,0x67,0x16,0xca,0xf5,0x92,0xcf,
  0x01,0x01,0x63,0x14,0xfb,0x6a,0x42,0xc8,0x79,0xcb,0x4a,0x25,0x16,0x80,0x13,0xc1,
  0xac,0xd1,0xc8,0xf7,0xac,0x4e,0x9f,0x59,0x01,0xdb,0x87,0x17,0xbe,0xf5,0x8c,0xb7,
  0x2f,0xb8,0x0f,0xe2,0x40,0xcc,0x7b,0x01,0x0f,0xa5,0xef,0x96,0x33,0xe8,0xed,0x80,
  0xa4,0x02,0x1b,0xc3,0x07,0xf9,0x25,0xc4,0xf6,0xd0,0x0a,0xc7,0xbe,0xe5,0xb2,0x2f,
  0xcf,0x0f,0x8f,0xd8,0x08,0x24,0x9a,0x0b,0x4d,0x0c,0x40,0xf2,0x41,0x9b,0x41,0x99,
  0x9d,0x79,0x6c,0xff,0xe2,0x82,0xc1,0xd8,0x3a,0x3c,0x10,0xa0,0x94,0xe0,0x43,0x5c,
  0x95,0xd9,0xb3,0x3e,0x17,0x42,0x8b,0x18,0x97,0x75,0x7d,0xec,0x94,0xeb,0x59,0x36,
  0x48,0xd5,0x2f,0x2f,0xa0,0x35,0xf8,0x05,0x52,0xba,0x57,0x96,0x0d,0x3d,0xa3,0xa9,
  0xb6,0x22,0x40,0x69,0xef,0x1f,0x92,0x0d,0x41,0x82,0xd8,0xf5,0x3a,0xaf,0x85,0xfc,
  0x8a,0x27,0x07,0x48,0x04,0x29,0xfa,0xe1,0x03,0x74,0x5d,0xf4,0x94,0x58,0x53,0x6a,
  0x1c,0xe8,0x22,0x03,0xf9,0x4f,0x10,0xac,0x36,0x88,0x49,0xa9,0x73,0x34,0x18,0xd8,
  0xd5,0x21,0x0a,0x4a,0x26,0xe7,0x24,0xd7,0x94,0x88,0x8e,0xad,0x78,0xf6,0x23,0xdb,
  0x33,0xc0,0xc6,0xd8,0xd7,0xcb,0x52,0x23,0x31,0x60,0x29,0xb5,0x7a,0x3e,0xd8,0x90,
  0x28,0x4f,0x26,0xcc,0x1b,0x0a,0x40,0x43,0xcb,0x07,0x05,0x13,0x09,0x74,0x54,0x79,
  0x61,0x1f,0xb4,0x2b,0x89,0x6b,0x36,0x1e,0xa1,0x4f,0x07,0xdc,0x91,0xa4,0x54,0x4e,
  0x12,0x1b,0x8c,0x9d,0x1c,0x03,0x72,0x77,0x38,0x28,0x0b,0xa0,0x1a,0xb3,0x79,0xd7,
  0x1a,0xbb,0x21,0x29,0x5e,0x90,0x6f,0x37,0x8d,0x8d,0x0a,0x2b,0xc0,0xa8,0x8b,0xa8,
  0x02,0x94,0xae,0x13,0x70,0x5c,0x52,0xe3,0xa8,0x66,0x61,0x82,0xb6,0x41,0xe2,0xb5,
  0x39,0xa0,0x88,0xeb,0x2a,0x95,0x66,0x6e,0xa0,0xa9,0x07,0xf1,0x9e,0x0c,0xa2,0x48,
  0x41,0xb4,0x91,0x1c,0xa6,0x2d,0x5e,0xa9,0x24,0x66,0x22,0xc8,0x93,0x16,0x8c,0x83,
  0x2b,0x6b,0x5c,0xcc,0x3c,0x0d,0x1a,0x52,0xda,0x84,0xa8,0x97,0x40,0x9b,0x4e,0x93,
  0xd9,0x2d,0x13,0xfd,0xca,0xbc,0x84,0xb1,0xc2,0x37,0xc3,0x8c,0xa3,0x19,0xb8,0x80,
  0x75,0x2f,0x5f,0x1b,0x83,0xb0,0xf0,0x5f,0x01,0x81,0xc4,0x98,0xed,0xf8,0xbc,0x43,
  0x06,0x96,0x10,0xe6,0xa4,0xf3,0x36,0x52,0xc6,0xda,0x86,0x14,0x1b,0x71,0xd7,0x19,
  0x4c,0xf1,0xe1,0xad,0x29,0x2d,0x74,0xfb,0x6d,0x43,0x4a,0x53,0x55,0x05,0x5d,0x76,
  0x4d,0xda,0xd4,0xca,0x0d,0x55,0x00,0x3a,0x50,0x6a,0x5b,0x76,0x8f,0x47,0xa8,0x22,
  0x53,0x53,0x8a,0x1e,0xf4,0x11,0xd0,0x54,0xcc,0xb0,0x7e,0x69,0x14,0xb2,0x07,0xdd,
  0x6e,0x57,0x6f,0x7e,0x6d,0x43,0x17,0xc1,0x35,0x29,0x82,0x13,0x83,0x8a,0x34,0xbb,
  0xee,0x31,0xac,0x03,0x99,0x53,0x42,0x6c,0x15,0x80,0xa5,0x94,0xae,0xb0,0x46,0xb9,
  0xe5,0x1a,0xc2,0xbc,0xc2,0x57,0xbb,0xab,0xdd,0x56,0xdc,0xad,0xb7,0xa2,0x50,0x86,
  0x9d,0x5a,0x69,0x6f,0x76,0x36,0x3b,0x09,0xe9,0xb8,0x37,0x06,0x51,0x3b,0x0c,0x0c,
  0xf1,0x58,0x6e,0x87,0xc3,0x12,0xaa,0xde,0x45,0xec,0x17,0xb4,0x8c,0x50,0x21,0x2b,
  0x42,0x6a,0x78,0x54,0xca,0x0f,0xe1,0xdd,0x4a,0x75,0xa3,0x99,0xf5,0x3a,0x5f,0x2b,
  0xd4,0x6d,0x4a,0x9d,0x99,0x34,0xd5,0x63,0xbc,0x49,0x7a,0x57,0xb3,0x5c,0x2f,0xcd,
  0x7e,0xb7,0xc0,0xe0,0x40,0x1b,0xbe,0x75,0xdd,0x07,0xa6,0x25,0xdc,0x72,0x68,0x1c,
  0xa7,0x09,0x75,0xa9,0x67,0xaa,0x44,0x6b,0xbd,0x5b,0x5f,0x37,0xb1,0xd8,0xcb,0x32,
  0xf5,0xb9,0x55,0x69,0x08,0xa7,0xce,0xfc,0xb0,0xc6,0xab,0xf5,0x6a,0xdd,0x04,0xe0,
  0x67,0x00,0x88,0xbd,0xa5,0x72,0xdb,0xec,0x41,0x15,0x7c,0x84,0x0d,0x13,0x40,0x96,
  0xb3,0x51,0xdf,0xd8,0x68,0x77,0x6d,0x02,0xe0,0x19,0x1f,0xd6,0x3b,0x0d,0x5e,0x49,
  0x00,0xf0,0x32,0x00,0xd8,0xb5,0xcd,0xcd,0x5a,0x4d,0xe0,0xc0,0xb7,0x26,0x8b,0x7a,
  0x32,0x69,0x3b,0x21,0x02,0x91,0xd5,0xcb,0xb8,0xc4,0x68,0xec,0x8f,0x5c,0x6e,0x7e,
  0xb5,0xab,0x9d,0x75,0xcb,0xec,0xaa,0x28,0x96,0x01,0x6a,0x8d,0x37,0x2a,0x1d,0x81,
  0xb1,0x09,0x77,0x5d,0xef,0xda,0x1c,0xb5,0xb5,0xda,0x89,0x7d,0x6e,0x01,0x4a,0x14,
  0x9b,0x31,0xf4,0x2c,0xf3,0xe0,0xbb,0x31,0x48,0xb8,0x70,0xc2,0x50,0x91,0x18,0x73,
  0x21,0xf8,0xae,0x04,0xef,0xb2,0x1d,0xdb,0x0c,0xa1,0xa8,0xb3,0x7f,0x3a,0x34,0xf1,
  0x36,0x86,0x08,0xaa,0xa3,0xcd,0x5d,0xc3,0x20,0x5a,0x4d,0x1b,0x44,0x53,0xb8,0x37,
  0xe0,0x09,0x29,0x20,0x02,0x37,0xf3,0xdc,0x65,0x49,0x51,0xc3,0xbd,0x40,0x7b,0x71,
  0x3d,0xd3,0x5b,0x4e,0xdb,0x6a,0xc6,0x9c,0x54,0x1d,0x69,0x76,0xbd,0xce,0x38,0xb8,
  0x05,0x35,0x88,0xca,0xc9,0x98,0xe0,0x09,0xef,0xd7,0xc0,0xfb,0xa9,0x27,0x0c,0x2e,
  0xa1,0x0e,0x4c,0x9c,0x0f,0xe8,0x5b,0x49,0x7e,0xbb,0xd3,0x48,0x45,0x1c,0xc4,0xb4,
  0x60,0x2b,0xba,0x05,0x5b,0x9b,0x22,0xa3,0x64,0x9b,0x1f,0x24,0xb2,0x95,0x30,0x63,
  0x2b,0x66,0x13,0x14,0xe1,0xbb,0x4d,0x05,0x1f,0xa6,0xc4,0x91,0x04,0xcd,0xf4,0xfa,
  0x60,0x50,0x84,0x80,0xf0,0x45,0x42,0x56,0x6b,0xaa,0x65,0x2d,0x98,0xb4,0x11,0xc7,
  0x92,0x36,0x32,0x43,0x49,0xd3,0x54,0x5f,0x22,0xfa,0xb3,0x16,0x47,0x7f,0x8c,0xc0,
  0x49,0x3d,0x88,0x9b,0x2c,0x27,0xa8,0x97,0x1d,0x94,0x5a,0x8b,0x83,0x52,0xb2,0xea,
  0x94,0xb9,0x31,0x05,0x45,0xb3,0x3a,0x41,0x90,0xb0,0x1b,0xb2,0xac,0xde,0x8c,0x40,
  0x27,0x28,0xa7,0xe0,0x1d,0x14,0x5d,0x4a,0x8c,0x20,0x51,0x18,0x85,0x48,0x4c,0xf9,
  0x91,0x60,0xa6,0xd9,0x9c,0x93,0x41,0x47,0x63,0xb6,0x22,0xaa,0x2a,0xd3,0x23,0xa4,
  0x52,0x80,0x27,0x15,0xa5,0x98,0xaa,0x7e,0xd3,0xb5,0x94,0xd7,0xab,0xab,0x63,0xa1,
  0x8d,0xc8,0x22,0xd2,0x2d,0x98,0xcd,0x14,0x73,0x24,0x02,0xa0,0xe5,0xf5,0x7a,0x06,
  0x51,0x62,0x68,0xa5,0x2c,0x1d,0x5b,0x8b,0x54,0x54,0xc4,0x0b,0xa9,0x99,0x4c,0x1f,
  0x1a,0x3a,0xa4,0x2c,0x25,0x5a,0x4b,0xd2,0x3f,0x0d,0x49,0x7c,0x30,0x20,0x4d,0x32,
  0x34,0x42,0x0c,0x49,0x3c,0x67,0x40,0x12,0x1f,0x10,0x92,0x41,0xf5,0xc3,0x2b,0xa0,
  0x51,0x82,0xe0,0xfc,0x0a,0x04,0x8b,0xe7,0xb6,0x2d,0x3f,0xad,0x34,0x36,0x52,0xee,
  0x33,0xc9,0xa3,0xc5,0x02,0xa4,0x00,0xb8,0x03,0xdd,0x0e,0x17,0x74,0xa2,0x31,0x00,
  0x47,0x01,0x23,0x55,0x79,0x51,0x8b,0xce,0xe7,0x23,0x6e,0x85,0x05,0xac,0x5a,0xc2,
  0x28,0xd7,0xf2,0xc0,0x19,0x82,0xb3,0x50,0xa8,0xd6,0x57,0x47,0x37,0xcb,0x30,0x05,
  0x8a,0x45,0x1a,0xcc,0xa6,0x14,0x2e,0xd8,0xaf,0x64,0x8c,0x41,0x32,0x62,0xda,0xd0,
  0x43,0xa5,0xdc,0x25,0xf5,0xec,0xd8,0x76,0xb4,0x08,0x30,0x4d,0x9a,0x1b,0x01,0xd9,
  0x40,0x6f,0x4d,0xa9,0xf7,0x29,0x61,0x56,0x55,0x8c,0x5c,0x22,0xcd,0xcb,0xb1,0x82,
  0x11,0x28,0x15,0xe8,0x10,0xc0,0x6c,0x36,0x56,0xea,0x2d,0xaf,0xfd,0x0a,0x5f,0x80,
  0x9d,0x0d,0x1e,0x09,0x40,0x6c,0xa5,0xfd,0x27,0x00,0x75,0x05,0x78,0x22,0x8f,0x22,
  0x9a,0x20,0x38,0x15,0x28,0x2a,0x41,0xc4,0x52,0x73,0x55,0x8f,0xf0,0xa7,0xb5,0xb9,
  0x82,0xe6,0x0c,0xbb,0xde,0xad,0x1e,0xae,0x5e,0x4f,0xcc,0xab,0x99,0x35,0x59,0xfb,
  0xd6,0x54,0xe7,0xa6,0x0f,0x69,0xb2,0x57,0x4d,0xf9,0x1c,0x69,0x43,0x22,0x45,0x0a,
  0x1a,0x4e,0xf4,0x12,0x8c,0x28,0x67,0x14,0x38,0x11,0xd2,0xad,0x4e,0x18,0xa4,0x19,
  0xba,0xa1,0xa9,0xd6,0x0a,0x8e,0x03,0xff,0xd7,0xab,0x30,0x6b,0x39,0xfa,0xd9,0x26,
  0x5f,0xe3,0x16,0x2b,0x37,0xab,0x33,0xb1,0x27,0x1d,0x2a,0x43,0xf4,0xd5,0x71,0xb5,
  0x27,0xd3,0xa9,0x22,0x48,0x36,0xef,0x78,0x44,0xd6,0xa1,0xb1,0x74,0x40,0xbf,0x33,
  0x0c,0x97,0xa8,0x7b,0x19,0x56,0x78,0x6d,0xb5,0x95,0xc9,0x50,0xfa,0x20,0xe6,0xcb,
  0x23,0xb9,0xf4,0x63,0xd9,0xa5,0x81,0xe7,0x73,0xe1,0xee,0xa7,0xc7,0xac,0x9b,0x22,
  0x8d,0xb4,0x56,0x01,0xcf,0x10,0xc6,0x6e,0x4a,0x18,0x67,0x38,0x1a,0x87,0x2f,0x68,
  0x35,0x1a,0xa6,0x47,0x8f,0x7f,0x6b,0x30,0x78,0x07,0x01,0x9b,0x13,0x42,0x45,0x8f,
  0x91,0xd5,0x84,0x2c,0x04,0x10,0x7a,0xa5,0x3b,0x1b,0x58,0x26,0x03,0x2a,0x0a,0xad,
  0x67,0x6a,0x8d,0x84,0x29,0x49,0xc6,0x8e,0xea,0xc4,0xe2,0xb6,0x23,0xe2,0xb2,0x6d,
  0x98,0x04,0x19,0x92,0x2f,0x6b,0x26,0x90,0x4b,0x59,0x61,0x75,0xc9,0x96,0xa1,0xd7,
  0xeb,0xb9,0x3c,0x6d,0xd2,0xdf,0x59,0x2d,0xeb,0x51,0xde,0x8a,0x02,0x7d,0x1b,0x2d,
  0x39,0xfa,0xdc,0xa5,0xe0,0xa2,0xf4,0xe3,0x1b,0xb5,0xd8,0xea,0xaa,0x65,0xf8,0xb7,
  0xe9,0xb5,0x38,0x80,0x26,0x28,0x7d,0xeb,0x61,0x5c,0x20,0x9c,0x34,0x2b,0x12,0x56,
  0xa5,0x65,0x04,0x80,0xa0,0x60,0x29,0x70,0xe3,0x96,0xad,0x36,0x45,0x33,0x79,0xcb,
  0x19,0x06,0x1c,0x0a,0xb5,0xe6,0xca,0xe5,0x38,0xce,0xba,0x90,0x20,0xae,0x05,0x5a,
  0xbb,0x4d,0x11,0xf0,0xba,0x55,0x78,0xcb,0xe7,0x5b,0xe9,0x9e,0x48,0x56,0x5b,0xd3,
  0x56,0x31,0xd7,0xa2,0x26,0xb5,0xde,0x49,0x32,0xa6,0x4d,0x52,0x9c,0x1e,0x88,0x35,
  0xd2,0x69,0xf8,0x23,0xbb,0x3f,0x02,0x61,0xcd,0x4e,0x9f,0x77,0x5e,0x73,0xfb,0x9f,
  0x2b,0xd4,0x64,0x78,0xfa,0x26,0x93,0x69,0x46,0xe1,0x54,0x28,0x6a,0xa0,0x71,0x14,
  0x9a,0x7e,0xa1,0xe6,0xfc,0xba,0x80,0xea,0xa0,0x68,0x1a,0xce,0x29,0x87,0xe7,0xd2,
  0x03,0xeb,0xcb,0x34,0x15,0x42,0x7c,0x85,0x8b,0xf9,0x31,0xf5,0x28,0xea,0xdb,0x52,
  0xc6,0x01,0x6a,0x4c,0x5f,0x20,0x6c,0x23,0x11,0x94,0x92,0x51,0xfc,0x69,0x64,0x13,
  0xc6,0x95,0x69,0x6a,0x19,0x41,0x96,0xd5,0xac,0xa0,0x5b,0x3a,0xce,0x42,0xae,0x89,
  0x11,0x28,0x53,0xeb,0xe7,0x9b,0x9b,0x9b,0x5a,0x0c,0xb1,0x5e,0xa9,0xc4,0x4c,0xa4,
  0x59,0xf7,0x0d,0xb9,0x46,0xcf,0x30,0xa0,0x09,0xff,0x6c,0x08,0x13,0xaa,0xac,0x7c,
  0x3b,0x1d,0xf4,0xdb,0xe8,0xb5,0x5c,0x71,0xcd,0x08,0x66,0xa2,0x40,0x85,0x31,0x64,
  0x48,0x52,0x53,0x14,0x44,0x8a,0x7a,0x23,0x21,0x7e,0xa2,0x40,0xa1,0xed,0x80,0x56,
  0x07,0x13,0x42,0x71,0x64,0x02,0xbf,0x72,0xa6,0x48,0x21,0x42,0x7b,0x0d,0x22,0xeb,
  0x6f,0xdf,0x73,0x5d,0x0b,0x94,0x23,0x06,0x7c,0x3b,0xb4,0x1c,0x10,0xf9,0xb1,0x6a,
  0x05,0x30,0x2a,0x80,0xfe,0xc5,0x34,0x59,0x6b,0xcc,0xc6,0xbb,0xb9,0xed,0xd4,0x21,
  0x5a,0x8e,0x49,0x13,0x51,0xc3,0x0d,0x4e,0x98,0xb9,0xcb,0xde,0xa9,0xa0,0x24,0xfa,
  0x56,0x1f,0xc2,0x03,0x56,0x8b,0x43,0x26,0x36,0xb2,0xe2,0x6a,0x76,0xbd,0x5e,0x6f,
  0x4f,0x17,0xfd,0x09,0x08,0xac,0x4c,0x11,0xff,0x5b,0x4d,0x0a,0x44,0xd3,0x92,0x95,
  0x6b,0xab,0x81,0x1c,0x23,0x6e,0xa1,0x01,0xce,0xf2,0x07,0x96,0xdb,0x4a,0x3a,0x93,
  0x59,0x70,0xcb,0xde,0x88,0x9b,0xc0,0x69,0xa2,0xfb,0x1e,0x38,0x77,0xbc,0xb0,0x59,
  0xb1,0x79,0xaf,0x98,0xae,0x87,0x3b,0x6e,0xa6,0x85,0x92,0x55,0x20,0x3b,0x59,0x81,
  0x5a,0xca,0x60,0x6f,0xe0,0x26,0x15,0xf6,0x48,0xc7,0x09,0xd6,0x53,0x71,0x82,0xf5,
  0xd8,0x09,0x96,0xaa,0xfe,0x8e,0xcb,0x65,0x6b,0x00,0x50,0xb1,0x78,0x83,0x14,0xe5,
  0x5a,0x6c,0xd1,0x29,0x23,0xb2,0x61,0xaa,0x87,0xa9,0x7e,0xe7,0xdb,0xa5,0xad,0x15,
  0xb9,0x6d,0x69,0x6b,0x45,0xee,0xcf,0xc3,0xc1,0xca,0xdd,0x7a,0xdc,0xc7,0xed,0x4c,
  0x5b,0x30,0xef,0x58,0x07,0x3c,0xd1,0x60,0x3b,0xd7,0xb7,0x7d,0x10,0x26,0x43,0xee,
  0xe7,0x76,0x08,0xfe,0x16,0x06,0xf9,0xd5,0x47,0x5c,0x2f,0x95,0xef,0xcd,0x5a,0x6a,
  0x97,0x4a,0x8e,0xe1,0x32,0x2f,0x3e,0x1d,0xc0,0xc3,0xce,0xd6,0x0a,0x94,0x51,0xe5,
  0xbf,0xf8,0xbc,0x5a,0x5b,0xdf,0xac,0x56,0x5a,0x6c,0xea,0x56,0x2b,0xd1,0xe2,0x0a,
  0x36,0x49,0xfd,0x52,0xd5,0xb7,0x86,0x96,0x04,0xb3,0x25,0x6c,0x3d,0xd5,0x6e,0x68,
  0xb5,0x99,0x90,0x4b,0x39,0xe6,0x0d,0x3b,0xae,0xd3,0x79,0xbd,0x9d,0x0b,0xfa,0xde,
  0xf5,0xa5,0xd5,0x2e,0xe4,0x71,0xa9,0x39,0xbf,0x1c,0xf6,0x9d,0xa0,0x98,0xdb,0xc1,
  0xe6,0x37,0x6a,0x60,0x47,0xb2,0x13,0x78,0xbd,0xb5,0x22,0x00,0x4d,0x83,0x2a,0x06,
  0xc2,0xc9,0x97,0x04,0x58,0x7b,0xe1,0x30,0xab,0x01,0xf1,0x3d,0xd1,0x44,0x63,0xa3,
  0x25,0x9d,0x50,0x81,0x3b,0x01,0x28,0xdc,0x43,0x5f,0x37,0xc7,0x88,0x18,0xdb,0x39,
  0x83,0x39,0x33,0xa2,0x3b,0xda,0x9a,0xc6,0x1c,0x87,0x5f,0x5f,0xe5,0xa8,0x4a,0xc7,
  0x45,0x77,0x37,0x23,0x5b,0x4f,0xe3,0x4f,0x98,0xeb,0xa1,0xd3,0xb1,0x5c,0x29,0x91,
  0x06,0xe0,0x6c,0xb8,0x1c,0xc9,0x45,0x98,0xd7,0x71,0xb3,0xb5,0x42,0xa8,0x17,0xbc,
  0x83,0xdc,0xb2,0xb4,0xf5,0x59,0xa9,0xc4,0x4e,0x8e,0x9f,0x1e,0xb2,0xcb,0xdd,0x3d,
  0x56,0x2a,0xc1,0x47,0x64,0x04,0x63,0x79,0x5f,0x21,0x52,0x49,0x60,0x49,0x22,0x59,
  0x54,0x7e,0x8c,0x96,0x11,0xe1,0x3d,0xb6,0x84,0x70,0x7f,0xf8,0xfb,0x7f,0x2f,0xfe,
  0x63,0x27,0x87,0x0f,0x2e,0xd9,0xfe,0xa3,0x93,0x27,0xa7,0x67,0xda,0x5b,0x6c,0x4e,
  0x70,0x1e,0xd5,0x91,0xb5,0x64,0xbc,0x18,0x11,0x0a,0x8c,0x24,0xca,0x98,0xfc,0x49,
  0x7e,0xa7,0x5a,0x10,0x17,0xb4,0x8d,0x37,0x10,0xc4,0x1c,0xdd,0xaf,0x29,0x1a,0x6e,
  0x0a,0x36,0x91,0xa0,0x61,0xf8,0xb5,0x2c,0xb6,0xd7,0x16,0xfa,0x74,0xa0,0xcf,0xf0,
  0x59,0x95,0xcf,0xac,0x41,0xeb,0x9b,0x71,0x85,0x47,0xf0,0x18,0x97,0x4f,0x4c,0x3a,
  0x6d,0xf5,0x2c,0x62,0xb1,0xf5,0x56,0x3c,0x4b,0x8c,0x4a,0x3b,0x12,0x17,0x4e,0xc0,
  0x1e,0x3d,0x78,0xc0,0xbe,0x18,0xd8,0x56,0xd0,0x6f,0xb1,0x91,0xcf,0x83,0x00,0x03,
  0x62,0x7e,0x88,0x2b,0xa8,0xb8,0x2c,0x9b,0x04,0x60,0xcc,0x55,0x46,0x6b,0xe6,0x5a,
  0x0f,0x8f,0x07,0xbd,0x4c,0xde,0xcd,0x31,0xcb,0x0d,0xb7,0x73,0x84,0x2b,0x51,0x32,
  0xc6,0xa6,0x0e,0x50,0xc7,0x41,0xb4,0xda,0x27,0x50,0x00,0x8f,0x62,0x6e,0xc0,0xe0,
  0x36,0xd7,0xd6,0x01,0xf3,0x8f,0x0f,0xf7,0xa7,0x56,0x16,0x91,0x7a,0x1d,0xbb,0x14,
  0x4e,0xdc,0x79,0x1c,0x6d,0x18,0x68,0x6e,0xad,0x88,0x57,0x71,0x91,0x80,0xbb,0xc0,
  0x89,0x31,0x57,0xba,0x3a,0xf2,0xa1,0x26,0xcd,0xed,0x3e,0x3a,0x6e,0xc0,0x2a,0xf4,
  0xb7,0x40,0xe3,0x57,0x62,0x05,0xa2,0x50,0x34,0xa9,0xe3,0x8d,0x88,0xab,0xaf,0x2c,
  0x77,0x0c,0x15,0xaa,0xb9,0x9d,0xaf,0xbe,0xc2,0x05,0xf8,0xea,0x5a,0xe5,0xa6,0x5a,
  0xab,0x6c,0xad,0x88,0xef,0x33,0xaa,0xac,0x42,0x15,0xac,0x51,0xaf,0x55,0x6e,0x6a,
  0x8d,0x45,0x6a,0xac,0xe5,0x76,0xf6,0x8f,0x1f,0xb0,0x46,0x05,0x2a,0x6c,0xae,0x2d,
  0x50,0x61,0x3d,0xb7,0xf3,0x10,0x9b,0x68,0x6c,0x54,0x6e,0xea,0x0b,0x75,0x6a,0x03,
  0x08,0x4c,0x78,0xe2,0xf6,0x0e,0xd6,0x94,0xcb,0xec,0x0b,0xd4,0xdc,0xcc,0xed,0xe0,
  0x0e,0x34,0xb6,0x01,0xbd,0x03,0x3b,0x65,0x81,0x1a,0xd5,0x4a,0x6e,0xe7,0x6b,0x44,
  0x59,0xa5,0xd6,0xb8,0x59,0x5f,0xdb,0x58,0xa4,0x4a,0x0d,0x5a,0xa1,0x3a,0x35,0x18,
  0x12,0x56,0x5c,0xa4,0x52,0x3d,0xb7,0xf3,0xe4,0x6b,0x41,0x1b,0x22,0x4e,0x46,0xe7,
  0x60,0x22,0xd0,0xb0,0x53,0x2c,0xf5,0xe0,0xfc,0xe2,0xae,0xbc,0xf4,0x60,0xf4,0x7e,
  0xbc,0x04,0x8c,0xb1,0xca,0xba,0xa3,0x60,0x31,0x14,0xc6,0xf4,0xaa,0x56,0x16,0xad,
  0x05,0x2d,0x54,0x17,0x6d,0xa2,0x06,0x54,0xaa,0x4d,0x81,0x9c,0xc4,0x9a,0x36,0x61,
  0xe5,0xcf,0x58,0x3e,0xef,0x83,0xa4,0xf7,0x3d,0x57,0xc6,0x69,0x82,0x05,0x24,0x74,
  0x52,0x22,0x83,0xdd,0x00,0x5a,0x55,0xc2,0x09,0xa6,0x89,0x63,0xb5,0x46,0xae,0x4b,
  0x07,0x53,0xb3,0xa3,0xa1,0xda,0xd3,0x35,0x39,0x4a,0x44,0x41,0x9f,0x42,0x51,0x08,
  0xa0,0xd5,0x46,0x4b,0x0a,0x4a,0x25,0xfb,0x75,0x4b,0x61,0x0a,0x4c,0xdf,0x80,0xe9,
  0x8d,0x0c,0x90,0xb5,0xca,0x26,0x82,0xf4,0x46,0x77,0x81,0xd8,0xd6,0x20,0x86,0xd6,
  0x6b,0x7e,0xde,0xf7,0x42,0xaf,0xd0,0xb5,0xdc,0x80,0x1b,0x96,0xc6,0x25,0x7c,0x63,
  0xf4,0x71,0x21,0xb0,0x62,0x21,0x36,0x13,0x76,0xe8,0x8f,0x05,0xe8,0xcd,0x8d,0x0d,
  0xe8,0x30,0xbd,0x64,0xf7,0xd8,0x03,0xa8,0xdc,0x5f,0x08,0xb6,0xa7,0x81,0xf5,0x31,
  0xf4,0x67,0x3f,0x05,0x6f,0xce,0x2b,0x54,0x2b,0xb2,0xc7,0xeb,0x9b,0x88,0x89,0xc7,
  0xf4,0x09,0xa6,0x7e,0xf0,0x5e,0x50,0xeb,0x99,0x50,0xeb,0x0b,0x42,0xc5,0xfd,0x18,
  0x1a,0x60,0x34,0xfd,0x05,0x71,0x9e,0x81,0x27,0xed,0x5d,0x03,0xe5,0x94,0xb6,0xa3,
  0x80,0xbc,0x88,0xc3,0x37,0x49,0x2d,0xd7,0x14,0xfa,0xc1,0x7d,0x67,0x8f,0xd0,0x3b,
  0x51,0x3a,0x77,0xc8,0xce,0xf8,0x35,0x50,0xa4,0xbd,0x50,0x17,0xc4,0xf2,0xba,0x31,
  0x3a,0x62,0xc7,0xc3,0x8b,0xf3,0x85,0x9a,0x5f,0xab,0xe0,0xa8,0xa9,0x0a,0x83,0x3a,
  0xf5,0x5a,0xb2,0xd5,0x59,0x53,0x52,0x2e,0xf5,0x1e,0xf0,0x50,0x99,0x68,0xfe,0x00,
  0xca,0x04,0xf0,0xd7,0x5d,0xa6,0xa7,0x56,0xc2,0x58,0xac,0xd5,0x67,0xa0,0x6e,0xcb,
  0xe8,0xcb,0xad,0x72,0x1c,0x95,0x35,0x30,0xc9,0x93,0xdd,0x49,0x19,0x27,0xe9,0x86,
  0xc4,0x92,0xab,0x29,0x4c,0xf5,0x52,0xb1,0x3b,0x22,0x2a,0xa4,0x1d,0x92,0x74,0xef,
  0xc4,0xd2,0xa4,0x5e,0xeb,0x84,0x5e,0xec,0x1c,0x1c,0x5f,0xec,0x3e,0x3e,0x3d,0x3c,
  0x98,0x69,0x34,0x4d,0xb5,0x59,0xb4,0x55,0xcd,0x88,0xae,0x89,0x4d,0x09,0x77,0x10,
  0x59,0x3c,0x14,0xd8,0xd2,0x26,0xec,0x26,0x4e,0xd8,0xc3,0x21,0xed,0x76,0x13,0x1f,
  0xef,0x2e,0xb5,0x22,0xb0,0x9a,0x8c,0xa9,0x54,0x90,0xc9,0x0e,0x80,0x2d,0xa6,0x43,
  0xd6,0x59,0xcb,0x64,0xae,0x80,0x53,0x24,0xe0,0x0a,0xf7,0x70,0xdc,0x63,0x1d,0xcf,
  0x73,0x61,0x66,0x0d,0x59,0xc1,0x19,0x62,0x64,0x79,0x99,0x0d,0x71,0x6b,0x23,0xb8,
  0xc4,0x62,0xa3,0x7c,0xc4,0x76,0x12,0x77,0x19,0x78,0xd2,0x56,0x36,0xa2,0x8d,0x02,
  0xca,0x3d,0xa2,0xe7,0xa4,0xf7,0x9b,0x32,0x13,0x23,0x47,0xb6,0xed,0x1a,0x9c,0x73,
  0x11,0x77,0xb5,0x09,0x3c,0x01,0x5a,0x66,0x28,0xad,0x5f,0xf8,0xf0,0x14,0x44,0xc5,
  0xce,0x6a,0x05,0x1d,0x69,0x7c,0x9f,0x66,0x1f,0xd9,0xd5,0xa9,0x3b,0xe1,0x28,0xb8,
  0x91,0xdb,0x61,0x85,0x3e,0x78,0x60,0xe0,0xa1,0x6c,0x33,0x5c,0x7e,0x88,0xf0,0xc3,
  0x8b,0x69,0xb6,0x4a,0x5a,0x1d,0x14,0xff,0x94,0xc7,0xdd,0x68,0x85,0x21,0x17,0x75,
  0x4f,0xf6,0xfb,0xc2,0xc5,0xd0,0x59,0x8e,0x0d,0x9c,0x21,0xda,0xa4,0xb8,0x95,0x13,
  0x8d,0x04,0xb0,0x12,0x94,0x6d,0x51,0xc9,0x69,0x3d,0xf7,0x86,0x04,0x12,0xac,0x79,
  0xaf,0x33,0x1e,0x80,0xb7,0x5a,0xee,0xf1,0xf0,0xd0,0xe5,0xf8,0x73,0x6f,0x72,0x6c,
  0x17,0xf2,0x72,0xe8,0xf9,0x62,0x19,0x63,0x17,0xfb,0xf2,0xa0,0x1e,0xba,0xba,0x65,
  0x82,0x98,0xf4,0x70,0x12,0xde,0xc1,0x02,0x21,0xfc,0x99,0xeb,0x6b,0x7a,0xc8,0xa6,
  0x66,0x4c,0x10,0xe5,0xea,0x9c,0xa0,0x4f,0x13,0x21,0x51,0x39,0xaf,0xf4,0xe7,0xa9,
  0x81,0xdf,0x79,0xae,0x4e,0x9a,0x35,0xf6,0x15,0xb3,0xca,0xae,0x82,0x97,0xc3,0x71,
  0x17,0x6b,0x01,0x3c,0x5a,0x6f,0x68,0x07,0xc5,0xe6,0x6c,0x12,0x0d,0xc7,0x83,0x36,
  0x12,0x43,0xc2,0x84,0x4f,0x82,0x5e,0x6a,0x12,0x1c,0x63,0xd9,0x9c,0x66,0x79,0x13,
  0xd5,0x6a,0x92,0x6a,0x75,0xa4,0x9a,0x44,0xa7,0x08,0x53,0x6e,0x26,0x45,0x84,0xbf,
  0x83,0xff,0x2f,0x6a,0x40,0x04,0xd6,0x15,0x17,0x93,0x12,0xc8,0xd8,0x75,0x7a,0x9a,
  0x7e,0x89,0xc3,0xa0,0x06,0x86,0x49,0x34,0x57,0x37,0x61,0xf6,0x5f,0x40,0x5d,0x35,
  0xa3,0xd5,0xda,0x97,0x86,0xc9,0xb9,0x2a,0x27,0x8a,0xe3,0x90,0x68,0xe0,0xb8,0xcd,
  0x59,0x3b,0xfd,0x80,0x93,0x3e,0xed,0xfc,0x3f,0x3e,0x3e,0x7a,0xb8,0xb0,0xf7,0xff,
  0xcc,0x79,0xe0,0xb0,0x2f,0xd8,0x25,0x98,0xa3,0x3d,0x1f,0xd4,0x70,0x41,0x0b,0xec,
  0xc5,0x52,0x45,0xb4,0x20,0xc3,0xfe,0xce,0x80,0x63,0x09,0xce,0xd0,0xfd,0x57,0x6f,
  0xef,0x6a,0x95,0x82,0x5d,0x57,0x6f,0xc5,0xb0,0x52,0x46,0xe9,0xdd,0xe7,0xc3,0xf4,
  0xbd,0x6b,0xda,0xb6,0xa5,0x94,0x6a,0xa5,0xc8,0x8b,0x2b,0x36,0xbb,0x44,0x64,0x9d,
  0xb9,0x28,0x97,0xdb,0x39,0x3e,0xdb,0xdd,0xbf,0x3c,0x7e,0x7a,0x98,0x9a,0x19,0xc6,
  0x54,0x08,0x3d,0x50,0x3c,0xa4,0xab,0xb7,0x73,0x42,0xbb,0x90,0x89,0x80,0xba,0x20,
  0x54,0xc3,0x36,0xe7,0xa5,0x3e,0x07,0x68,0xb1,0xa6,0xed,0xdd,0xe4,0x64,0x0f,0x2f,
  0x69,0x99,0x4f,0x77,0x8f,0x40,0xe7,0x44,0xe8,0x4b,0xfa,0x45,0xba,0x5e,0x16,0xab,
  0x3d,0x51,0x7c,0x6a,0x9a,0x98,0x34,0xf5,0x6f,0x7a,0x52,0x1f,0x23,0x46,0x61,0xca,
  0xc5,0xb3,0x38,0x09,0x60,0x91,0x29,0x1c,0xba,0x0a,0x4e,0x34,0x7f,0xeb,0x95,0x84,
  0xd8,0xad,0x83,0xb7,0x19,0x0b,0xdb,0xb9,0x03,0xfe,0xb1,0xc5,0x67,0x3d,0xcd,0x35,
  0x3b,0x55,0x10,0x66,0x5d,0x2b,0x08,0xc1,0x80,0x2c,0x1a,0xa2,0x13,0xfb,0x0e,0xdf,
  0xaa,0x7d,0x3f,0xa1,0x96,0xd2,0xe6,0x8d,0x40,0xc7,0x19,0x68,0x87,0xe3,0x61,0xd7,
  0xcb,0xe2,0x3d,0x11,0x1e,0x9f,0xda,0xb1,0x0d,0xec,0xd8,0x34,0x33,0xd5,0x14,0x69,
  0x89,0x65,0x81,0x38,0xd0,0x2c,0x9e,0x62,0x7f,0x86,0xb8,0x4c,0xae,0x06,0xf1,0x42,
  0x1e,0x8b,0xe4,0x35,0x54,0xd3,0x88,0xa2,0x28,0x9a,0x14,0x1e,0xd6,0x60,0xd4,0x8a,
  0x05,0x08,0x48,0xb9,0xf1,0x28,0x31,0x76,0x9d,0x1d,0x69,0x2d,0x22,0x72,0x16,0xf5,
  0x82,0x89,0xa8,0xb2,0x11,0xec,0x34,0x17,0x1b,0xf4,0xfe,0xe3,0x63,0xb6,0xe8,0xc9,
  0xb2,0x16,0x37,0x34,0x62,0x6e,0x8d,0x08,0x8c,0x35,0x3a,0xf5,0x6c,0x7e,0xe6,0x85,
  0x0b,0xc4,0x97,0xab,0x9d,0x5a,0xbb,0xda,0x99,0xba,0xc5,0xab,0x15,0xb1,0x49,0xf6,
  0x3a,0xe5,0x46,0xf6,0x3e,0xfa,0xe4,0x86,0x02,0x3f,0x5a,0xc3,0x98,0x22,0xba,0x88,
  0x02,0xf5,0x0a,0x38,0xb0,0x8f,0xc7,0xc3,0x21,0x1e,0xde,0x03,0xef,0x69,0xf7,0x1c,
  0x0c,0x23,0x9b,0x47,0x51,0x4b,0xdc,0xe9,0x84,0xef,0x27,0xde,0xd8,0x17,0x94,0xea,
  0xf8,0xdc,0x86,0x89,0xe0,0x80,0x89,0x4a,0x47,0x51,0x50,0xb1,0x61,0x40,0x13,0x26,
  0xc8,0x10,0xa3,0x32,0xf0,0x93,0x0a,0xc3,0x60,0x43,0x79,0x0e,0x88,0xc8,0x32,0x9a,
  0x21,0x16,0x08,0xf0,0xc5,0xc5,0xf1,0x41,0x73,0x96,0x38,0x40,0x1b,0x28,0x2d,0x0c,
  0x90,0x80,0x58,0xd5,0x38,0xac,0xb2,0x9d,0xfb,0x26,0xea,0xf0,0x10,0xe6,0xaa,0xe7,
  0xbf,0xa6,0xbc,0x07,0xb9,0x79,0x9d,0x38,0x87,0x67,0x28,0x6d,0xcf,0xec,0xc8,0x48,
  0x16,0xca,0xee,0x0c,0x82,0x48,0x74,0x86,0x40,0x47,0xb5,0xb2,0xfc,0x13,0xb9,0xec,
  0x9a,0x70,0x8f,0x32,0x7a,0x19,0x4d,0x91,0xbd,0x47,0x97,0xec,0xd2,0x7b,0xcd,0x87,
  0xef,0xd8,0x55,0x60,0x0a,0xaa,0x9e,0xe8,0xea,0x39,0x0a,0x24,0x04,0xfe,0xf2,0xf2,
  0xd1,0x2f,0x0f,0xcf,0x18,0x18,0xcb,0x33,0xb1,0x16,0xf5,0x67,0x1f,0x8f,0x46,0xbd,
  0x13,0x05,0x41,0x34,0x87,0xd9,0xf4,0xeb,0x08,0x98,0xc9,0xc9,0x16,0xf6,0xa6,0xab,
  0xda,0xe9,0x5b,0xff,0xc4,0x2e,0x51,0xfc,0x17,0xb1,0x1c,0xb3,0x63,0x6c,0xc4,0x2d,
  0x60,0xc2,0xed,0xc7,0xdc,0x3f,0xcf,0x82,0x4b,0xd8,0x6f,0x42,0xc2,0x3d,0xe6,0x6d,
  0xcf,0x0b,0x97,0xb2,0x4c,0xb7,0x94,0x10,0x8e,0xac,0xb5,0x48,0x46,0x29,0x5b,0x2d,
  0x0a,0xea,0xc5,0x0b,0xee,0xe2,0xfc,0x5d,0xbc,0x35,0x2a,0x32,0xa5,0x16,0x90,0xe1,
  0xb8,0xbc,0x4a,0x0f,0x53,0x1c,0xe3,0xe9,0xa2,0x1d,0x6a,0x66,0x4a,0xf6,0xf5,0xf5,
  0xf5,0xd5,0x56,0xb2,0x4f,0x3f,0x89,0x3c,0xa7,0xb1,0x08,0x71,0x1e,0x33,0x4d,0x24,
  0xcf,0x13,0xcb,0xc8,0x39,0xad,0xb3,0xc7,0x74,0xb8,0x2e,0x8e,0x6f,0x8e,0xb2,0xa6,
  0x69,0xb6,0x31,0x9a,0x39,0x31,0xf6,0x68,0x87,0xca,0x10,0x1d,0x24,0xdd,0x9b,0xbd,
  0x12,0xef,0x73,0x3b,0xb1,0x33,0xbb,0x90,0xab,0x49,0xc6,0x4d,0x45,0x1a,0x37,0x8d,
  0xc8,0xee,0xa9,0x49,0x27,0x54,0x42,0xbd,0x93,0x77,0x29,0xbb,0x92,0xf0,0x2e,0x0b,
  0xb1,0x7b,0x59,0xaa,0x15,0x5b,0x80,0x33,0xf0,0xcc,0xa1,0x74,0x3b,0x1a,0x8f,0x58,
  0x6c,0x8d,0x8a,0xfc,0xd4,0x4e,0xa8,0xe0,0xb2,0x52,0xcd,0x30,0x99,0x2a,0xc6,0xd3,
  0xbd,0xe8,0x63,0xc2,0xcd,0x34,0x1c,0xb6,0x2c,0x9f,0x13,0xa8,0x8f,0xfb,0x91,0x0c,
  0x8a,0xa9,0xb7,0x1f,0x9a,0x66,0x11,0xdc,0xbb,0x51,0x4d,0x55,0x5b,0x90,0x6e,0x1d,
  0x55,0xfc,0x93,0xa5,0xda,0x05,0x9d,0xe2,0x25,0xef,0xd8,0xa0,0x1b,0xbc,0xff,0xd0,
  0x24,0x43,0x90,0x77,0xa3,0x16,0xd4,0x58,0x90,0x50,0x41,0x34,0x8c,0x4f,0x98,0x54,
  0x7d,0xcb,0x1f,0xa5,0x65,0x22,0xbd,0xfe,0xe0,0xb4,0x22,0xa0,0x77,0xa4,0x16,0xd6,
  0x59,0x94,0x5e,0x6a,0x2c,0x9f,0x30,0xb9,0x46,0xbc,0x03,0xa6,0x0e,0x3b,0xec,0x76,
  0x41,0x6d,0xce,0x5b,0x88,0x8d,0x0c,0xba,0x40,0x94,0x37,0x96,0x61,0x23,0xac,0x09,
  0x90,0x2f,0x39,0x15,0xd1,0x51,0x37,0x73,0x55,0x16,0x6c,0xb6,0x33,0xda,0xb1,0x16,
  0x2d,0x83,0xa6,0xb7,0x00,0x9c,0xf1,0x9e,0x25,0x62,0x8d,0xf3,0x97,0x55,0x73,0x3b,
  0x47,0x3e,0x9f,0x50,0x5a,0xb3,0x69,0x10,0xeb,0xb9,0x9d,0xc7,0xdc,0x66,0x97,0xce,
  0x30,0x5c,0x00,0x62,0x83,0x20,0xf2,0xa1,0x59,0x3e,0xbd,0xb6,0xbc,0x07,0x3f,0x16,
  0x85,0xb9,0x06,0x14,0xe0,0x23,0xc7,0x5a,0x78,0xe9,0xf7,0x0e,0x16,0x4f,0x03,0x1c,
  0x6f,0x3c,0xfc,0xc0,0xf6,0x2c,0xd7,0x1a,0x76,0xf8,0x5d,0x0d,0x9e,0x69,0x9c,0xfd,
  0x01,0x4e,0x05,0x4e,0x8f,0x42,0x21,0x53,0x9a,0x46,0x6a,0x13,0x18,0x63,0x17,0x73,
  0xc5,0x24,0x06,0x93,0xda,0x99,0x93,0x8a,0xaa,0xed,0xcc,0x8a,0x94,0xed,0x3e,0xdb,
  0x03,0x3f,0x45,0x6c,0x75,0xce,0xe2,0x62,0x3a,0x37,0xd2,0xb6,0x5c,0xc9,0xbf,0xb2,
  0xe4,0xfd,0x6a,0x13,0x57,0x44,0x67,0x05,0xce,0xd2,0x73,0x28,0x31,0x23,0x3f,0x26,
  0xbc,0x3e,0xdb,0x63,0x47,0x96,0x33,0xfc,0x10,0xd8,0x3c,0x9a,0x89,0x4e,0xeb,0xba,
  0xfd,0xb2,0x07,0x2d,0x7d,0x78,0x74,0x66,0xb8,0xf9,0x7b,0x0c,0x43,0x35,0x8b,0x0b,
  0xb3,0x67,0x7b,0x58,0x3e,0x53,0x98,0x41,0xb7,0x31,0x5a,0x72,0x17,0x29,0x86,0xcc,
  0x3a,0x43,0x86,0x5d,0x8c,0x87,0xc3,0xc9,0x62,0x02,0x6c,0xdf,0xf5,0xc6,0xf6,0x64,
  0x86,0xf4,0x7a,0xd4,0xed,0x3a,0x1d,0xbe,0x98,0xec,0x7a,0xe8,0x0d,0xf8,0x07,0x17,
  0x33,0x1b,0xd5,0xb5,0x6a,0x8b,0x1d,0xde,0x8c,0x3c,0xcc,0x61,0x22,0x3d,0x60,0xc1,
  0x51,0x3f,0x6f,0x61,0x13,0x0d,0xa9,0xb0,0x7b,0xb8,0x5f,0x7c,0xff,0xf9,0x71,0xb8,
  0x3f,0x73,0x7a,0x70,0xd9,0xdc,0xcb,0x4e,0xe8,0x7f,0xda,0x22,0xe7,0x8c,0x12,0xf1,
  0xe0,0x7c,0x23,0xd4,0xd6,0x3e,0x08,0x6e,0x6b,0x99,0x73,0xd7,0xe2,0x9d,0xda,0x4f,
  0x21,0x6f,0x76,0x0f,0xd9,0xbe,0x37,0x18,0xf1,0x61,0x90,0xe1,0xa2,0xec,0x1e,0x9e,
  0x7c,0x68,0xb3,0x17,0x41,0xde,0xcd,0xe8,0x85,0x1a,0x0b,0x9a,0xbc,0x16,0x7f,0xe9,
  0xf2,0x2b,0xee,0x7e,0xba,0x16,0xef,0xa9,0x35,0x1c,0xa3,0xc1,0xab,0x26,0x78,0x82,
  0x5a,0xfb,0x4f,0x73,0x3b,0xf5,0xca,0xfb,0x10,0x0c,0x37,0x40,0x6a,0xab,0x56,0x95,
  0x88,0x6a,0x00,0xfa,0xae,0x64,0xdb,0x7f,0x3a,0x75,0x67,0x80,0x4e,0xb3,0xce,0x4b,
  0x7a,0x35,0x4d,0x4b,0xfd,0x84,0x24,0x33,0x69,0x24,0xf6,0x82,0xce,0xa7,0xd2,0xc7,
  0x26,0xfd,0x51,0x83,0x81,0x78,0x3a,0xfa,0x10,0x92,0xff,0x68,0xb6,0xe4,0x47,0xa3,
  0xe8,0x47,0x92,0xfa,0x53,0x79,0x9f,0x86,0x67,0xf2,0xfd,0xd1,0xfe,0xd1,0xfb,0x89,
  0xa9,0x7a,0xcc,0xf3,0x11,0xc7,0x23,0xd0,0x3b,0x72,0x3c,0x54,0x59,0x84,0xe3,0x7b,
  0x1d,0xdd,0x9a,0xfc,0x78,0x18,0xbe,0x5e,0x79,0x37,0xa1,0x44,0x14,0xd9,0xe7,0x0e,
  0xa6,0x6b,0x5b,0xdc,0x6e,0x45,0xd6,0x9a,0xc2,0x52,0x1d,0x01,0xeb,0x2e,0x76,0x6b,
  0xed,0x66,0x86,0xd5,0xda,0x98,0xfa,0x11,0xec,0xd4,0x8d,0x9b,0x05,0x4c,0x50,0x30,
  0x57,0xab,0x6b,0x53,0xa1,0x80,0x81,0x5a,0x9f,0xde,0x01,0xf0,0xaa,0xd7,0x1a,0x37,
  0x8b,0xf9,0xd3,0x60,0x94,0xde,0x7c,0x78,0x3b,0xb7,0xb6,0x89,0xab,0x1d,0x9e,0x2f,
  0xb3,0xb8,0x05,0xd2,0xd4,0x7d,0xe4,0x3b,0xc0,0x46,0x96,0xd8,0xb2,0xf7,0xb3,0xb5,
  0x78,0xf7,0x5c,0xcc,0xf6,0x7a,0x4e,0x49,0x0f,0xe3,0x31,0xbe,0xb7,0xe8,0xdb,0x3b,
  0xcf,0xe6,0xcf,0xf6,0xa8,0xf3,0x49,0x9b,0xb8,0x22,0x50,0xf1,0xc1,0xd1,0xf9,0xec,
  0x7c,0xb6,0x26,0xb9,0xfe,0xc4,0xd1,0x7a,0x02,0x06,0xf6,0x87,0xc4,0xe7,0xc9,0xe1,
  0xd9,0x6c,0x84,0xba,0x7c,0xf8,0x69,0x63,0xf4,0xa1,0xe7,0x3b,0x6f,0xf0,0x80,0xa0,
  0xcb,0x4e,0x1d,0xdf,0xf7,0xfc,0xf7,0xc6,0xe9,0xc3,0xd3,0xe3,0xc7,0x99,0x73,0xbe,
  0x3f,0xa0,0x06,0x3e,0x69,0x74,0x3e,0x95,0x07,0x3e,0xd9,0x03,0xd7,0x19,0xbd,0x37,
  0x2a,0x9f,0x3e,0x38,0x39,0x3e,0xcf,0xc4,0xe5,0x55,0x17,0xe0,0x7f,0xd2,0x98,0x3c,
  0xd8,0x7f,0xc6,0x0e,0xbc,0xeb,0x21,0xda,0x62,0xef,0x8d,0x48,0x00,0x36,0x73,0x9a,
  0xdb,0x9d,0xeb,0x4f,0x1a,0x99,0xfb,0x60,0xc5,0x8e,0x7d,0x76,0xc9,0x83,0x90,0xed,
  0x59,0xef,0x3f,0xc7,0xf7,0xf7,0x76,0xb3,0xe7,0x38,0x99,0xcb,0x6d,0xeb,0x47,0x98,
  0xe4,0xe6,0x2e,0x6c,0xfd,0x01,0x37,0xc9,0x7c,0xbd,0x7f,0xf2,0x4b,0x76,0xfa,0xf0,
  0x0d,0x2b,0x81,0x2b,0x22,0xf2,0x2e,0x27,0x72,0x55,0x47,0xd9,0x9d,0xe3,0xe3,0x0f,
  0x99,0x66,0xb8,0x82,0x94,0xee,0xd0,0x1d,0xe8,0x99,0x91,0x10,0xb6,0x91,0xa4,0x5a,
  0xd6,0x1e,0x58,0x44,0xee,0x4d,0xc7,0x7d,0x9d,0xd8,0xa7,0xde,0x88,0x1d,0xab,0x9a,
  0x71,0xb8,0x80,0x99,0x7b,0x93,0xd6,0x2a,0x89,0x44,0x1e,0x77,0xcb,0x8d,0x99,0xde,
  0x6a,0xa8,0x27,0xca,0x4c,0x26,0x13,0x11,0x67,0x2d,0xf4,0x11,0xcd,0xd9,0x58,0xc5,
  0xc3,0xaf,0x61,0x68,0xda,0x86,0x2a,0x23,0x6d,0x7b,0x2d,0x23,0x55,0x12,0xae,0x8c,
  0x85,0x19,0x27,0x6c,0x66,0xb1,0x06,0x72,0x83,0x3c,0x02,0xca,0x02,0x3a,0xaa,0xc1,
  0x64,0x22,0x73,0x72,0x59,0x33,0xb2,0x98,0xb3,0x42,0xa3,0xb4,0x56,0x5f,0x66,0x2e,
  0xa6,0x47,0xd8,0x6e,0x53,0x9a,0x88,0xe2,0x3c,0x36,0x51,0x4d,0x18,0x2e,0xb4,0x7c,
  0x89,0x0e,0xc8,0x3b,0xb8,0xd1,0x0d,0x49,0xed,0xb5,0x7a,0x4e,0x3b,0x8b,0x2b,0xdc,
  0x3c,0x05,0xf9,0x6e,0xae,0xb4,0xac,0xb5,0x80,0x37,0x2d,0x53,0xc0,0x7e,0x04,0xce,
  0x74,0x83,0x15,0xda,0xa9,0xbd,0xd2,0x6b,0x75,0x56,0xb8,0xf6,0x7c,0xed,0xf5,0x3c,
  0x16,0x38,0x39,0x3c,0x60,0xb8,0x7f,0x1c,0x4f,0xa6,0xc4,0x8c,0x30,0x9b,0xa6,0x66,
  0x1d,0x83,0xb2,0xf0,0xe9,0xfd,0x62,0x23,0xb5,0xd5,0xd5,0x54,0x70,0x04,0x81,0xde,
  0x8d,0xa0,0x50,0x63,0x01,0x62,0xba,0xdc,0x7e,0xe9,0xa8,0x71,0x7c,0x04,0x24,0x7d,
  0xd4,0xed,0x1a,0xd4,0x7c,0x30,0x76,0xdd,0x45,0xe8,0x98,0x92,0x27,0xe6,0x19,0x4e,
  0x1e,0x8a,0x89,0xac,0x49,0x94,0x8c,0x04,0x1f,0x53,0xcf,0xdd,0x6c,0xc2,0x77,0x3a,
  0xd8,0xc9,0x43,0xb5,0x87,0x31,0xf4,0xd8,0x81,0xcc,0x7f,0x3f,0xef,0xe4,0x4d,0xd6,
  0x0e,0x4e,0xb5,0x2b,0xd1,0x3c,0xe1,0x62,0x6e,0xb7,0xd4,0x2e,0x87,0x88,0xb6,0x01,
  0x6b,0x09,0x36,0xe8,0x96,0x2a,0x95,0x50,0xf5,0xee,0xc7,0xb7,0x37,0x6a,0x95,0x5a,
  0xcb,0x84,0x92,0x3a,0x2e,0x23,0x0e,0xd1,0xe3,0xa7,0x73,0x6b,0x88,0xc9,0x48,0x34,
  0xe8,0x32,0xc3,0x14,0x4c,0x05,0xf1,0xe3,0x8b,0x3e,0xa5,0x42,0x6c,0xc9,0x81,0xce,
  0x38,0xe7,0x7a,0x71,0x80,0x27,0xaf,0x7d,0xdc,0x5d,0x79,0xa7,0x6e,0x7f,0x10,0x0b,
  0x29,0x75,0xe8,0x42,0xdb,0x95,0x1b,0xf5,0x2b,0x75,0xa8,0x25,0xe3,0xf8,0xa7,0x6f,
  0x4d,0x0c,0x1e,0xeb,0x02,0x9b,0xf5,0x2f,0x0e,0x90,0xc3,0x08,0x6d,0xf6,0x63,0xf1,
  0x6a,0x4f,0xdb,0x47,0x3b,0x2d,0x47,0x4c,0x5d,0x66,0x04,0x8c,0xad,0xb0,0x2f,0x3e,
  0xdf,0x58,0xab,0xaf,0x22,0xcf,0x11,0x90,0x34,0x67,0x65,0x52,0x8a,0x3a,0xff,0x41,
  0x48,0x95,0x60,0x57,0x5f,0xbf,0x72,0x88,0xf6,0x1c,0xcb,0xa2,0xc9,0x63,0x64,0x98,
  0x73,0x04,0x13,0x00,0x89,0x32,0xf8,0xfa,0xf0,0xe9,0xe1,0xd9,0xe5,0x45,0x76,0x62,
  0x1a,0x91,0xab,0x27,0x99,0x9a,0x46,0xe5,0xa4,0x49,0xa8,0xfe,0xaa,0x32,0x8b,0x52,
  0x27,0x32,0x64,0xe7,0xe3,0x4c,0x31,0x98,0x97,0xc0,0x1a,0x85,0x63,0xbc,0xc6,0x48,
  0xe6,0x9e,0x15,0x01,0xb8,0x53,0xbc,0x4f,0x27,0x46,0x9e,0x0e,0x29,0xce,0x47,0x9b,
  0x5b,0x70,0xfb,0x37,0xa2,0x55,0x40,0x8f,0x8f,0xfd,0xd2,0x19,0xf4,0xf5,0xe9,0x74,
  0x9b,0x7d,0xe0,0xd7,0xe6,0x2e,0x0f,0xf9,0xae,0xeb,0x3e,0x70,0x5c,0x1e,0x14,0x14,
  0xc4,0x06,0x1e,0xc7,0x3e,0xa0,0x6f,0x6c,0x17,0xe5,0x61,0x02,0xa8,0x6e,0x2b,0xab,
  0xec,0xb7,0x2a,0x59,0xd2,0x3e,0x3d,0xec,0x98,0x3b,0xa8,0x63,0x82,0x9b,0x08,0xa0,
  0x44,0x0d,0x5a,0x96,0xa5,0x23,0x3d,0x71,0xc3,0xe2,0x1c,0x35,0xab,0x15,0x33,0xd3,
  0xa7,0x68,0x0c,0xdf,0xe1,0xe9,0x50,0xca,0xd1,0x93,0x99,0xd1,0x66,0x06,0xfe,0x12,
  0x13,0x51,0xc1,0x92,0x84,0x29,0x8a,0xa9,0x54,0xc5,0x14,0x53,0xf0,0x85,0xe1,0xa7,
  0x29,0xbb,0xec,0x0d,0x8e,0x5e,0x8a,0x8e,0x4a,0x6a,0x1c,0x8b,0x69,0x08,0x73,0xb1,
  0x53,0x22,0x93,0x12,0xc6,0xb2,0x79,0x2b,0xe8,0xf8,0xce,0x28,0xdc,0x59,0x5a,0x59,
  0xd1,0xf3,0x5d,0x73,0xf9,0xf0,0xd1,0xfe,0xb7,0x04,0x9c,0xc5,0xf8,0x15,0xe8,0x5e,
  0x54,0x70,0xdb,0xac,0xd2,0x5a,0x02,0xd9,0x09,0xfe,0xdf,0xe1,0xd3,0x97,0xe7,0xbb,
  0x47,0x87,0xf0,0xaa,0x06,0xef,0x44,0xa9,0x4b,0x0f,0x03,0x40,0x4c,0x14,0xd3,0x46,
  0x2a,0x8f,0xa3,0x12,0xe3,0x30,0x4a,0x25,0xc4,0xfe,0x89,0x46,0xf2,0x72,0xe4,0xf3,
  0x2b,0x4a,0x95,0x41,0xcc,0x0f,0x3d,0x2d,0x55,0x45,0xef,0x5f,0x8a,0x53,0xff,0x94,
  0xda,0x48,0x7d,0x33,0x47,0x71,0x69,0xb5,0x83,0x8f,0x9d,0x5c,0x38,0xce,0xee,0x78,
  0x28,0x72,0x44,0xa8,0xbc,0x67,0x78,0x98,0x69,0x99,0xc1,0x84,0x28,0x32,0xbc,0x1e,
  0x2c,0xb2,0x0b,0xbf,0x1b,0x73,0x7f,0x72,0x41,0x8b,0x19,0x9e,0x0f,0xc2,0xa3,0x90,
  0xc7,0x7b,0xb1,0xc0,0x32,0xec,0x7a,0xfe,0xa1,0xd5,0xe9,0x17,0x00,0x07,0x3b,0x2c,
  0x2c,0x13,0x57,0x9f,0x38,0x41,0x58,0x06,0xc5,0xe4,0x5d,0xf1,0x42,0x5e,0x24,0x08,
  0xcb,0x17,0x8b,0xad,0x39,0xf0,0xa4,0xd8,0xd6,0x60,0x06,0x08,0x33,0x58,0x18,0x66,
  0xd2,0x76,0x45,0xd5,0x90,0x67,0xf7,0xe8,0x80,0x56,0x51,0x83,0x02,0x8a,0x20,0x06,
  0x81,0x10,0x30,0x17,0xe1,0x8c,0xcf,0x4e,0x97,0x11,0x5e,0xd8,0xf6,0xf6,0x36,0x53,
  0x89,0xe1,0x00,0x3f,0x2c,0x29,0xb9,0x5b,0x53,0x38,0x83,0x89,0x69,0xd0,0x86,0x87,
  0xa9,0x9d,0x55,0x69,0xe4,0xa0,0x49,0x68,0xb0,0xd0,0x2e,0xde,0xb6,0xcb,0x24,0xc2,
  0xca,0x52,0x82,0x6d,0xe7,0x51,0x84,0xe5,0x5b,0x6d,0xc3,0x18,0xcf,0xe7,0x5b,0x6f,
  0xe9,0xe2,0x31,0xb3,0x93,0x94,0x1e,0xaf,0x08,0xd3,0x4b,0x74,0x52,0xd8,0x65,0x05,
  0x00,0x8d,0x4f,0xc2,0xf4,0x54,0xa7,0x67,0xf0,0xed,0xdb,0xa5,0xb7,0x06,0xf7,0x6a,
  0xb9,0x53,0x7f,0x06,0xbc,0x4b,0x22,0xb4,0x30,0x08,0x7a,0xcb,0xe2,0x64,0xa3,0x60,
  0x5d,0xfa,0x09,0x18,0x17,0x7f,0xff,0xf5,0x5f,0xb3,0xbc,0x3c,0xf0,0x98,0x6f,0xd1,
  0x57,0xa4,0x08,0x78,0x63,0x33,0x48,0x42,0x70,0x05,0x0b,0x70,0x57,0xc7,0x3a,0x66,
  0x79,0x08,0x7a,0xf2,0xbd,0x20,0x92,0x08,0x64,0xec,0xeb,0x6d,0x1a,0xdf,0x3b,0x53,
  0xbf,0xa8,0xcb,0xcf,0x80,0x6a,0x94,0x98,0x52,0x74,0xcf,0xe5,0x96,0x8f,0xe7,0x89,
  0xbd,0x71,0x58,0x80,0xa2,0x2f,0x43,0xd5,0x8d,0x97,0xd8,0xba,0x3c,0x6c,0x8c,0x1f,
  0x0b,0x45,0x9c,0x24,0x59,0xd0,0x88,0x5d,0x96,0x59,0x7d,0xb5,0x52,0x81,0xca,0x06,
  0x81,0x8d,0x4b,0xda,0x3e,0x52,0xf2,0xae,0xac,0x60,0x87,0xd3,0x77,0xc6,0xa9,0x11,
  0x16,0xe6,0x5d,0x15,0x57,0x2c,0x23,0x80,0xbb,0x5c,0x12,0x87,0x26,0x75,0x0b,0x73,
  0x97,0x68,0xd7,0xc3,0x01,0x08,0x75,0x39,0x9c,0xb8,0x51,0x11,0xc8,0x28,0x72,0xd8,
  0xd2,0x45,0x72,0xae,0xe7,0xbd,0x1e,0x8f,0x18,0xdd,0x46,0x06,0x30,0x39,0xb7,0xb9,
  0x5d,0x96,0x7d,0xbf,0x34,0x2f,0xdf,0x94,0x97,0x97,0x8d,0x03,0x28,0x38,0xef,0x72,
  0xca,0xa8,0xeb,0x22,0xa1,0x82,0xbc,0x5b,0x14,0xbb,0x35,0xe5,0x7e,0x51,0xfd,0xf6,
  0x52,0x19,0x76,0x44,0x10,0xa9,0xbb,0x46,0xa9,0x7a,0xf6,0x4d,0xa3,0x4f,0x8f,0x76,
  0x4b,0x94,0xec,0xad,0xb4,0xa3,0xae,0x1b,0x95,0x10,0xb0,0xfd,0xe5,0xe8,0x76,0x49,
  0x3c,0x9c,0x9b,0xbc,0x53,0x94,0x61,0xd7,0x07,0x16,0x2d,0x44,0xb8,0x13,0xea,0x3d,
  0xf2,0x32,0x5a,0x62,0x97,0xde,0x03,0xbc,0x3f,0x0f,0xf8,0xd4,0x1b,0xba,0x13,0x36,
  0x1e,0xd9,0x30,0x64,0xfd,0x16,0x54,0xba,0x6f,0x4c,0xbf,0x10,0x0e,0xc9,0x80,0x10,
  0xe4,0xf5,0x6f,0x12,0x6f,0xb6,0xc7,0x83,0x61,0x3e,0x64,0xaf,0xc6,0x83,0x11,0xb4,
  0x2f,0x6f,0xe8,0x0b,0xa2,0x9c,0x88,0x98,0x9b,0x6b,0xc4,0xed,0x15,0x99,0x6a,0x29,
  0x26,0x43,0xe2,0x36,0xbf,0x53,0x22,0xb8,0xb8,0xd3,0xcf,0xf2,0x7d,0xe0,0xae,0x60,
  0x59,0xf6,0x6a,0x46,0xa7,0x08,0x15,0x9e,0x88,0xf4,0x52,0xb1,0x21,0xbf,0x66,0xfa,
  0x4d,0x86,0x46,0x5f,0xc5,0x6d,0xaa,0xf2,0x8e,0x3a,0x90,0xcc,0x31,0x5c,0x84,0x13,
  0x77,0x96,0x70,0x19,0x77,0x58,0xdc,0xed,0x37,0x9f,0xd8,0x08,0x24,0xfb,0x2a,0x59,
  0x83,0x0c,0xac,0x84,0xbc,0xfc,0xa5,0x04,0x53,0x0a,0x84,0xc0,0x8f,0x98,0x34,0x92,
  0x9f,0x49,0x4a,0xc1,0x6c,0x51,0x22,0x14,0x85,0xe4,0x35,0x08,0x93,0xe4,0x65,0x87,
  0xb1,0x08,0xed,0x9b,0x5f,0xc5,0x95,0x87,0x4a,0x6b,0x5e,0xb3,0x1d,0x56,0x61,0x5f,
  0x7c,0x01,0xa5,0xe0,0x87,0x00,0xca,0x18,0xf4,0xfe,0x97,0x9c,0x8f,0xa6,0x92,0x1f,
  0x29,0x83,0x3c,0x80,0x73,0x9a,0x90,0x8a,0xde,0x20,0x11,0x4c,0x66,0xc3,0xc7,0x76,
  0xb1,0xd6,0x0c,0xd9,0x1d,0x25,0xdf,0x14,0xf2,0x9b,0x61,0x79,0x29,0x22,0xc5,0x34,
  0x86,0xca,0xd7,0x60,0x1b,0xe4,0x47,0x37,0xf9,0x64,0x01,0x31,0xbd,0xa1,0x40,0x5f,
  0x2b,0xa0,0x54,0x64,0x9c,0x8c,0x52,0xce,0xfd,0xa6,0xe8,0x1a,0x76,0x18,0x64,0x33,
  0x05,0xbd,0x58,0x69,0x87,0xbd,0x10,0x17,0xdd,0x4b,0x59,0xf1,0xad,0xb4,0x84,0x1f,
  0x1f,0x5e,0xbc,0x3c,0x38,0x3e,0xbd,0x00,0xe0,0xb7,0xd5,0xe6,0x8b,0xea,0x5a,0x65,
  0xb9,0x5a,0xab,0x7c,0xbb,0xbc,0xda,0x7c,0x01,0xf3,0x7e,0xb9,0xd6,0x80,0xdf,0x6b,
  0xcd,0x17,0x8d,0x0a,0xfc,0xde,0x5c,0xfb,0x76,0x79,0x1d,0x7e,0x6f,0x54,0x96,0xeb,
  0x58,0x06,0x3a,0xb1,0xd1,0x7c,0xb1,0xd6,0xa8,0x2c,0xc3,0xab,0x6f,0x97,0x37,0x9b,
  0x2f,0x36,0xa0,0xd8,0x5a,0x05,0x7e,0x57,0x2b,0x00,0xab,0x52,0x6b,0x2c,0xaf,0xaf,
  0x6d,0xc0,0x53,0x0d,0x9e,0x6a,0x50,0x0d,0x5f,0xc1,0x63,0x9d,0x1a,0xa2,0x96,0x2a,
  0xdf,0xbe,0x05,0x3b,0x35,0xb6,0xfa,0xf4,0x1c,0x79,0x44,0x1d,0xa1,0x4b,0xf3,0x3f,
  0xfc,0xa7,0x7f,0x14,0x99,0xf2,0x90,0x61,0x04,0x2e,0x41,0x20,0x80,0x36,0xc9,0xcb,
  0xcc,0xc7,0x02,0xad,0x62,0x50,0x78,0x8d,0xe4,0x36,0x08,0x03,0x3f,0xe0,0xc7,0xc3,
  0xb0,0x30,0x87,0x26,0x80,0x40,0x30,0xf1,0x44,0x70,0x30,0x86,0xd1,0x1d,0x05,0xf3,
  0xc9,0xf9,0x60,0x14,0x55,0xc5,0x9a,0x5d,0xbc,0xee,0xb2,0x90,0x5f,0xb1,0x46,0xce,
  0x8a,0x28,0xb0,0x42,0x03,0xba,0x0f,0x1d,0xda,0x46,0xc3,0x0f,0x3b,0x06,0x14,0xfc,
  0x02,0x80,0xd3,0x33,0xfc,0x5d,0x94,0x77,0xba,0x82,0x4c,0x90,0xaa,0xf3,0x76,0x49,
  0x25,0x45,0xc0,0x7e,0x60,0x6a,0xd4,0xb9,0xfd,0x38,0x1e,0xf4,0x14,0x5b,0x11,0x37,
  0x5f,0xa0,0x47,0x73,0x33,0x02,0xcf,0xd1,0x09,0x53,0xf7,0x8d,0x02,0x7b,0x78,0x03,
  0x31,0x53,0x65,0x4a,0x47,0x4d,0x6e,0x94,0x63,0x20,0x97,0x7d,0x98,0xf4,0x8e,0x9c,
  0xd3,0x86,0x6a,0x03,0x8d,0x61,0xb3,0xf6,0x24,0xb5,0x88,0x50,0x8a,0x1a,0x8d,0xa1,
  0x10,0xd7,0xad,0x48,0x0e,0xb6,0xc2,0xd0,0x77,0xc0,0x49,0x05,0x34,0x58,0xee,0x35,
  0x8a,0x24,0xa1,0x03,0x51,0x05,0x0e,0x49,0xb1,0x6a,0x5d,0x89,0x61,0xc4,0xf7,0x3e,
  0xc3,0xa4,0x40,0x39,0xb4,0x1c,0x5d,0xf6,0x49,0xf3,0x72,0x19,0x75,0xa0,0x52,0xc3,
  0xfa,0x6d,0x9f,0x11,0x16,0x61,0xf4,0x48,0x4e,0xc5,0xed,0x2f,0xa0,0x95,0x6f,0xd1,
  0x04,0x8b,0xb8,0x57,0x21,0x0f,0x25,0x47,0x34,0x1f,0xb1,0xd6,0x0b,0xf3,0x5b,0x34,
  0x15,0xe9,0x5b,0xd5,0xf8,0x06,0xea,0x04,0x5d,0xf1,0x6d,0xa6,0xd8,0xb9,0x20,0x6c,
  0x72,0x53,0x98,0x51,0xfe,0x66,0xb0,0x70,0xf5,0x9a,0x81,0xdf,0x41,0x03,0xa9,0x1f,
  0x86,0xa3,0xe6,0xca,0x0a,0x72,0x06,0xd4,0xa2,0xed,0x54,0xe5,0xbe,0x17,0x84,0x64,
  0x46,0x03,0xdf,0x34,0x37,0xaa,0x92,0xaf,0xee,0x63,0x99,0x03,0xd0,0x10,0xe5,0x21,
  0x26,0x10,0x34,0x60,0x4d,0x37,0xe2,0xf0,0x9f,0x45,0x04,0xd4,0x14,0xd3,0x4d,0x81,
  0x30,0xa6,0x64,0x7c,0xc7,0x29,0xb7,0x15,0x0f,0xbe,0x05,0xe7,0x06,0xf5,0x92,0x64,
  0x68,0x55,0xfe,0xbf,0xfd,0x8d,0x2a,0xcf,0xc5,0x26,0x08,0x98,0xbc,0x22,0x42,0x4d,
  0x8e,0xd3,0x5b,0x43,0x0e,0xc4,0x79,0x2d,0x69,0x42,0x64,0x4e,0x2d,0x8f,0x4e,0x30,
  0x26,0x67,0xce,0xbb,0xcd,0x1b,0x83,0x80,0xc3,0xb1,0xeb,0xc6,0xaf,0x25,0x75,0xf2,
  0xda,0x9b,0x19,0xf8,0x11,0x22,0x19,0x26,0x20,0xc6,0x81,0x46,0xc0,0xdb,0x82,0x9d,
  0x40,0x4f,0x1a,0x3a,0xa5,0x8f,0x26,0x8e,0xb4,0xfc,0xe4,0x85,0xb3,0xc2,0xce,0x78,
  0x77,0x22,0x61,0xdc,0x58,0x76,0x42,0xa1,0xfc,0xfb,0x3f,0xc7,0x24,0x22,0x05,0x4f,
  0x48,0x17,0xb7,0x59,0x89,0x91,0xbf,0x8d,0x4c,0x71,0x4a,0x2f,0xe9,0x5b,0xd7,0xd2,
  0x20,0x09,0xa2,0x44,0x93,0x16,0xd9,0x16,0x94,0xfe,0x3c,0x6b,0x9a,0x46,0x44,0x4b,
  0x27,0xb6,0xd4,0x94,0xb6,0x90,0xc9,0x8b,0x8b,0xe2,0x8f,0x41,0x12,0x5f,0xd3,0x30,
  0x28,0x57,0x7f,0xe1,0x0e,0x93,0x13,0x71,0xfc,0xb2,0xed,0x5a,0xc3,0xd7,0xc0,0xd7,
  0xf2,0x4a,0x73,0x6d,0x3a,0x7c,0x08,0xa8,0x8a,0x66,0xfb,0x60,0x56,0xa1,0x23,0x80,
  0x16,0x25,0x48,0x65,0x4a,0x24,0x32,0xec,0xf1,0x40,0xb7,0x04,0x41,0x36,0x3e,0x38,
  0xbf,0x60,0xb6,0xef,0x8d,0x30,0x1d,0x5c,0x50,0x5e,0x52,0x2c,0x1a,0x24,0x78,0x14,
  0x05,0xc5,0x32,0xc3,0xc4,0xa7,0x94,0xe1,0x26,0x90,0x3c,0xd0,0x4a,0x9b,0xce,0x4b,
  0x24,0xd9,0x5d,0x17,0x0a,0x97,0xc0,0x8a,0xe5,0xcc,0x4b,0xdf,0x4f,0xed,0x75,0x33,
  0xec,0x52,0xcd,0xca,0xcb,0x4c,0x58,0x9c,0xe2,0x98,0x9f,0x5e,0x8b,0xbf,0x8b,0xfc,
  0x90,0x75,0x02,0x31,0x1a,0xb4,0x51,0xb6,0x33,0x04,0xc5,0x67,0xdb,0xba,0xa8,0x50,
  0x73,0xf4,0xb7,0xff,0xe5,0xff,0xfd,0xe9,0x7b,0xcc,0x2a,0x33,0xec,0x61,0x45,0x0d,
  0x57,0x19,0x06,0x4e,0x06,0x63,0xcb,0x75,0xeb,0x77,0x33,0x32,0xd0,0x28,0xd6,0xba,
  0x5d,0x8c,0x3e,0x90,0x20,0x7b,0x22,0xbc,0x90,0xc8,0x94,0xd0,0x8d,0x08,0xcf,0xcf,
  0x20,0xaf,0x96,0xd1,0x29,0x4b,0xed,0x46,0xc4,0x84,0x1a,0xc5,0x6c,0x05,0x3c,0x5b,
  0x05,0xcf,0x56,0xc2,0x2c,0x1d,0x87,0xb8,0xd5,0xd6,0x3b,0x3f,0xa4,0xa6,0xd5,0x85,
  0xec,0x7f,0xfd,0x57,0xba,0x11,0x0e,0x13,0xca,0x75,0xa4,0xa0,0x95,0xf1,0x1d,0xad,
  0xd6,0xdb,0x65,0xb6,0x4e,0xe1,0x0f,0xf9,0xc8,0xb8,0x1b,0x70,0xad,0x97,0xd9,0x30,
  0x31,0x21,0x4f,0x36,0xc4,0xb7,0x73,0x14,0xae,0xda,0xa3,0x21,0x26,0x1b,0xeb,0x5a,
  0x8e,0x2b,0x21,0x99,0x9a,0x37,0x0e,0xc5,0x88,0x5c,0xcc,0x3f,0x9f,0x58,0x5b,0x9c,
  0xaf,0x1a,0x93,0x47,0xeb,0x4e,0x03,0xbd,0x60,0xf7,0x19,0x4c,0xb1,0x3f,0xc8,0x75,
  0x33,0x9c,0x60,0x78,0x3b,0x3c,0xa3,0x6f,0x38,0xc1,0x58,0x93,0xe5,0xff,0xf2,0xbb,
  0xbf,0xfb,0x53,0x5c,0x60,0xde,0xb4,0x1b,0x61,0x6b,0xf7,0x09,0x00,0xcd,0xaf,0xb8,
  0x9d,0x2a,0x41,0xab,0x44,0x52,0x9f,0xe6,0x9b,0x8f,0x14,0xf1,0xcb,0xaf,0x02,0xb4,
  0x07,0xa5,0xb9,0x62,0xeb,0xac,0x29,0x3a,0x6b,0x97,0xbd,0xd7,0xd4,0x57,0xa0,0xbc,
  0x20,0xc1,0xe7,0x08,0xdc,0x2e,0xd3,0xaa,0x17,0xf2,0xa4,0xe0,0x02,0xf6,0x05,0xe6,
  0x1a,0x0d,0x3f,0xa3,0xa6,0x90,0xc2,0xa2,0x14,0x59,0x54,0xcb,0xc6,0xb6,0x28,0x05,
  0x51,0xf1,0x0c,0x56,0x88,0xa8,0x3e,0xcf,0x50,0x93,0xcb,0x8c,0x8b,0x30,0x8c,0xca,
  0x0b,0xfd,0x33,0x60,0x16,0x3d,0xeb,0x35,0xe1,0x1f,0xc5,0xdf,0x67,0x1d,0xcc,0x53,
  0xea,0x0f,0x0a,0x79,0x35,0x12,0x94,0x6b,0x94,0xe5,0x9a,0xc1,0x9c,0xbf,0x0f,0x23,
  0x86,0x8a,0x80,0x8d,0xa1,0x26,0xb5,0xff,0xf2,0xbb,0xdf,0xfc,0x4b,0x35,0x72,0x8d,
  0x67,0x74,0xcb,0x4a,0xe7,0x19,0xd9,0x70,0xde,0xc4,0xf7,0xed,0xdb,0x24,0x2e,0xe5,
  0x62,0xd3,0xa3,0x33,0xb6,0x42,0x77,0x6a,0x7c,0x4c,0x0b,0x32,0x51,0xd2,0x66,0xcb,
  0x1f,0xa4,0x8d,0x72,0xb1,0xce,0x70,0x1f,0xbe,0x71,0x5b,0x4c,0x0b,0x4c,0xef,0xbd,
  0xd8,0xa4,0xd0,0x3e,0xd0,0xcc,0x10,0xc1,0x2f,0xd1,0xda,0x93,0x63,0x98,0x1a,0x04,
  0x55,0x30,0x5e,0xd4,0x9f,0x44,0x21,0x51,0x44,0x33,0x1f,0x6c,0x2f,0xa4,0xd5,0xbc,
  0xa9,0x2a,0x3c,0x4a,0xd5,0xad,0xab,0x70,0xb1,0x23,0x6a,0x6e,0x2d,0x4a,0xd5,0x1d,
  0x2f,0xc6,0x68,0x8d,0xa3,0xf1,0x1e,0x26,0x17,0x6f,0x70,0x11,0xa9,0x25,0x60,0xcf,
  0xfa,0x64,0x46,0xf4,0xf3,0x94,0x05,0x3c,0x61,0xd0,0x83,0x74,0x90,0x3c,0x62,0x47,
  0xe9,0xd4,0x45,0xb9,0xa4,0x76,0x30,0x54,0x8b,0xd9,0x27,0xb5,0x6a,0x95,0xdd,0xad,
  0xac,0xaf,0x89,0x9e,0xa9,0x14,0xe5,0x66,0xe7,0x60,0x4e,0xfc,0x7d,0xba,0x77,0x51,
  0xd9,0x94,0xe7,0x91,0x14,0x23,0x94,0x54,0xff,0xe7,0xa1,0x75,0xf4,0xcb,0x01,0x02,
  0xde,0x09,0x8c,0x58,0xd5,0x5f,0x7e,0xf7,0xb7,0xff,0x10,0x07,0xab,0x70,0x2e,0x60,
  0x11,0x14,0xe1,0x81,0xac,0x38,0x45,0x62,0x4c,0x65,0x3a,0x75,0x6d,0x4d,0x96,0xd7,
  0x17,0xbb,0xf7,0xa6,0xc0,0xc1,0x76,0xee,0x63,0xc3,0xdb,0xaa,0x07,0x77,0xd2,0x4a,
  0xef,0xd4,0x97,0x8c,0x30,0x81,0xae,0xd7,0x76,0x9f,0x1e,0x33,0xcc,0xfe,0xe8,0x91,
  0x0a,0xc3,0xf0,0xb5,0x4a,0xaa,0xf8,0xa3,0xa8,0xb3,0x0f,0x3d,0x14,0xea,0x9f,0x64,
  0xd3,0x0c,0xbd,0xa8,0xfa,0x90,0x5a,0xda,0xa2,0x8d,0x6c,0xe2,0x3e,0xe5,0x91,0xe7,
  0xba,0x01,0xee,0x25,0xf0,0x27,0x6c,0x15,0xb8,0xe6,0xa7,0xe0,0x55,0x7d,0xbd,0x35,
  0x23,0x96,0x82,0x1f,0x54,0x18,0x65,0x0e,0x57,0xc8,0xf0,0x3b,0x88,0xcc,0x59,0x12,
  0x52,0xde,0xc8,0x16,0x05,0x56,0x30,0xec,0x0e,0xcf,0x45,0xaa,0x28,0xe4,0xcc,0x19,
  0xad,0x0b,0xb3,0xbc,0xba,0xca,0x8d,0xf4,0x85,0x5d,0xc6,0x47,0x24,0x31,0xd1,0x16,
  0xe3,0xdf,0x08,0x43,0x6b,0xf9,0xae,0x22,0xfd,0xdd,0x85,0xba,0xe8,0xb6,0x52,0x3c,
  0xec,0xf6,0x83,0x0b,0x75,0x69,0xb8,0x93,0x88,0x56,0xff,0xdc,0xfe,0x78,0x62,0x9a,
  0xbd,0x5d,0x52,0xc1,0xa9,0xf4,0x7e,0x96,0x26,0x23,0x93,0x96,0x09,0x4b,0xd3,0x77,
  0x02,0xb2,0x92,0xfb,0xc0,0xe0,0x8c,0xc6,0x4f,0x77,0x08,0x50,0x25,0x74,0xf5,0xed,
  0x08,0x3d,0xc9,0xfd,0x28,0x3b,0xdb,0x62,0x6d,0x45,0xa2,0x4d,0xfc,0x24,0xd0,0x01,
  0xdb,0x49,0xee,0x5e,0x89,0x3d,0xcd,0xf4,0x16,0x85,0x7b,0xdb,0x88,0x7b,0x59,0xb3,
  0x94,0xaa,0xd9,0x32,0x42,0xbb,0x8b,0x6e,0x62,0xd0,0x1c,0xde,0x36,0x52,0xb4,0x9d,
  0xc0,0x56,0xaa,0x1b,0x2d,0xd6,0x4e,0x8b,0x05,0x71,0x9f,0x44,0x49,0x0a,0x5d,0xe5,
  0x7e,0xd1,0x9f,0xe9,0xed,0x39,0x6a,0x0c,0x06,0x13,0x5f,0xef,0x11,0x0b,0x0b,0x66,
  0xc7,0x7f,0xee,0x0b,0x2a,0x14,0xf2,0xfb,0x22,0xec,0x82,0x62,0x25,0xdf,0xa3,0xcd,
  0x12,0x4d,0xf5,0xe9,0xc0,0x09,0x3a,0xda,0x57,0xdf,0xe4,0xef,0x81,0x04,0x29,0xd0,
  0xae,0x83,0x24,0xf2,0x33,0x90,0xbd,0x11,0x48,0x1d,0x68,0xa4,0x99,0x93,0x00,0x7d,
  0x09,0x30,0xd2,0x56,0x31,0x40,0x4a,0xe5,0x2e,0x6a,0x30,0x13,0xdc,0xb1,0xed,0x72,
  0xf8,0x30,0x31,0x41,0x5d,0x8f,0xf7,0xc4,0x70,0xa9,0x73,0x4f,0x46,0x71,0xdf,0x1e,
  0x73,0xcb,0x9e,0x68,0xfd,0xd2,0x61,0x3d,0x83,0xd2,0xc8,0x85,0xe3,0x11,0xe9,0x49,
  0x01,0x74,0x5e,0x68,0x54,0xed,0xe7,0x05,0x69,0x46,0xb7,0x4a,0x3e,0xbc,0x3c,0x3d,
  0x61,0xdb,0x92,0xee,0x3e,0x78,0xef,0xf9,0x1f,0xbe,0xff,0x23,0xc6,0x5a,0x9e,0x8c,
  0x30,0xa5,0x3c,0x08,0x6f,0xa9,0x58,0xc6,0xf4,0x5c,0x64,0xf7,0xf4,0xb2,0xe0,0x14,
  0xfe,0x23,0xe5,0x55,0x56,0xe5,0x18,0x90,0x2e,0x5d,0xe6,0x8f,0xec,0xf8,0x3c,0x2e,
  0x81,0xd0,0x9c,0x51,0xba,0xd4,0x1f,0xd8,0xe3,0x8b,0x8b,0xe3,0xb8,0x1c,0xa0,0x36,
  0x08,0x1c,0xf2,0xea,0xec,0xbd,0x41,0x3e,0x55,0xe1,0x6f,0xfe,0x80,0xfd,0xbc,0xe4,
  0x83,0x91,0x5e,0x07,0xd7,0xe7,0xa9,0xce,0xff,0xfd,0x9f,0xfb,0xe9,0x3a,0x7f,0xfb,
  0xdf,0x55,0xac,0x17,0x63,0x61,0xcb,0xd4,0x48,0x14,0x42,0x48,0x77,0xe9,0x4f,0xc2,
  0xcd,0x0c,0x62,0x34,0x08,0x66,0x4d,0xc3,0xfd,0x07,0x46,0x86,0x8e,0x56,0x92,0x94,
  0x78,0xba,0xe4,0xf7,0xff,0x42,0x4a,0x17,0x55,0x72,0xb0,0x97,0x85,0x8a,0xd3,0x03,
  0xa9,0x14,0xa9,0x18,0x30,0x48,0xba,0xc9,0xdf,0xe2,0xf0,0xb5,0x8b,0x52,0xa0,0xa4,
  0x5d,0xd6,0x2e,0x20,0x49,0xd4,0x90,0x74,0x55,0x37,0x69,0x88,0xe6,0xd1,0x75,0x96,
  0x37,0x6b,0xa0,0xe9,0x95,0x46,0xd8,0xdf,0xfd,0x59,0x6a,0x73,0xca,0x10,0x80,0xef,
  0xd3,0x3d,0xf9,0x1f,0xbf,0x67,0x0f,0x7c,0xce,0xd9,0x43,0x6e,0x09,0x52,0xd8,0xe5,
  0x2e,0x3c,0xe3,0x23,0x23,0x52,0xfc,0x72,0x2f,0x0d,0xf8,0x3f,0xfe,0x1f,0x51,0xe9,
  0xfc,0xe2,0xf1,0xee,0xa9,0xa0,0x04,0x56,0x3a,0x0f,0x30,0x7d,0xb4,0xaa,0x34,0x97,
  0x9f,0x93,0xd7,0xad,0xa8,0x18,0x25,0x4d,0x27,0xed,0x6b,0x6b,0x3e,0x9c,0xd4,0xd5,
  0x2a,0xd4,0xdb,0xbb,0xc1,0x31,0xae,0x13,0x89,0xfa,0xa2,0xe0,0xa8,0xaf,0xba,0xf2,
  0x54,0x09,0xcb,0x8b,0xb3,0x6d,0x05,0x2c,0x62,0x8c,0x4d,0xbd,0x34,0x14,0x31,0xa5,
  0x9d,0x2f,0xce,0xea,0x60,0x9c,0x99,0x7e,0xb6,0x99,0xac,0x24,0x53,0xd8,0x3b,0x9c,
  0xbd,0xdb,0x4a,0x26,0xdf,0xd6,0x2d,0x02,0xac,0x53,0xa4,0x9a,0x09,0xed,0x01,0x93,
  0xb3,0x27,0xee,0x3b,0x19,0x2b,0x15,0xc9,0x94,0xd9,0x1b,0x65,0x0e,0xef,0x44,0x05,
  0xf2,0x4b,0x4a,0xe0,0xe5,0x7f,0xf8,0xed,0xef,0xc5,0x5c,0x97,0x85,0x86,0x5e,0xa8,
  0x15,0x64,0x3f,0xfc,0xfa,0x37,0x8c,0xb6,0xff,0xc7,0x79,0xd0,0x69,0x93,0x86,0xcc,
  0x42,0x9e,0x6f,0x45,0x8a,0xfd,0x62,0x32,0xec,0xa8,0x55,0x9b,0xef,0xd4,0xe9,0x2f,
  0xb9,0xa1,0x11,0xec,0x4f,0xc2,0x6f,0x00,0x1a,0x9d,0xc7,0xfb,0x03,0x00,0xf2,0x18,
  0x97,0x78,0x42,0xde,0xe3,0xbe,0xf4,0x0f,0x04,0xbe,0xa3,0xa0,0x3a,0x05,0xad,0xc7,
  0x43,0x9b,0x77,0x41,0xef,0xd9,0xc5,0xc4,0xea,0x74,0x30,0xdb,0xae,0xd2,0x42,0xf3,
  0x4a,0xff,0x42,0x0d,0x9d,0x8d,0x55,0x01,0x5d,0x3d,0x63,0x11,0xb5,0x34,0x7d,0x8c,
  0x77,0x8d,0xb3,0x2d,0xdc,0xab,0xa1,0xd7,0xcc,0x6f,0xe4,0xb5,0xe5,0xee,0x42,0x74,
  0xbd,0x2b,0x46,0x78,0x60,0x5c,0xd1,0x66,0x2a,0x77,0x82,0x7b,0x36,0xb4,0x1d,0x36,
  0x81,0xdc,0x62,0x43,0x4b,0x59,0x46,0xe8,0xba,0xa8,0xa9,0x72,0x1d,0x07,0x0f,0x46,
  0x29,0x1c,0x2c,0xbe,0x9e,0xa0,0x0d,0x12,0xde,0xea,0x0c,0x1d,0x5d,0x6a,0x92,0x04,
  0x2e,0xe2,0x1a,0x97,0x2e,0x05,0x3e,0xa2,0x52,0x28,0xff,0xe2,0xdb,0x40,0x30,0x72,
  0x5e,0xaf,0xc8,0xf5,0xbb,0xcc,0x90,0x92,0xe6,0xa9,0x46,0x07,0x38,0x88,0x76,0x57,
  0x96,0x8f,0xdb,0x4b,0xb7,0xa7,0x8f,0x41,0x3b,0xe0,0xa1,0x22,0x1c,0x05,0xdc,0x7f,
  0x7b,0x8b,0xbb,0x52,0x8d,0xad,0x9e,0x72,0x93,0x3c,0xaa,0xe8,0x16,0x7e,0x94,0x17,
  0xb6,0xd8,0xdb,0xb8,0xf9,0xb4,0xf5,0x36,0xe9,0x6a,0xd8,0xa8,0xa2,0x63,0x5f,0x63,
  0x7b,0x27,0xe9,0x69,0x6c,0xef,0xdc,0xce,0xd3,0xf1,0xd1,0x49,0x10,0x5d,0xc9,0x6f,
  0x27,0xc4,0xef,0xff,0xa2,0xbb,0x76,0xf2,0xcb,0x80,0x7a,0xfb,0x72,0x32,0xe2,0xc5,
  0xa4,0xe0,0xff,0x77,0x8c,0x76,0x7b,0xcb,0x12,0xf8,0xf3,0x5e,0x9e,0x9d,0x82,0x50,
  0x4e,0x16,0xfc,0x37,0xec,0x49,0xc0,0x25,0x24,0xfc,0x35,0xa5,0xd8,0xbf,0x25,0x79,
  0x2f,0x8a,0xe1,0x2f,0x59,0x4c,0xd1,0x7b,0x0a,0xfa,0x7e,0xf8,0xd7,0xff,0x5b,0x9d,
  0xa7,0x48,0xe0,0x8f,0xae,0x45,0x23,0x04,0x6a,0xe4,0x55,0xd8,0x79,0x4f,0x78,0xc4,
  0x1e,0x1a,0x7f,0xc0,0x10,0xc8,0x79,0x58,0xc6,0xad,0x42,0x82,0x47,0x44,0xb4,0x93,
  0xe5,0x8d,0xbb,0x70,0x7d,0x75,0x94,0x8d,0x16,0x4d,0xc8,0xa3,0x02,0x55,0x66,0x1c,
  0x6a,0xc3,0x2f,0xc8,0x9d,0xda,0x7b,0x3a,0x41,0x90,0x37,0x02,0x77,0xc2,0xc4,0xc3,
  0x9e,0x2f,0xd3,0x61,0xc1,0x44,0x9b,0xfa,0xa1,0x0f,0xb1,0xdd,0x9e,0xfe,0xa4,0x8d,
  0xd3,0x58,0x1c,0xa1,0xe7,0xa8,0x29,0x04,0xa1,0xb5,0x95,0x4f,0x38,0xde,0xf2,0x80,
  0x4c,0x0f,0x97,0x48,0xc1,0xdd,0x2e,0x8c,0xac,0x9e,0x03,0x62,0x01,0xe7,0xd8,0x4f,
  0x17,0x28,0xd2,0x76,0x64,0xd3,0x71,0xbd,0x38,0xec,0xac,0x3d,0xb2,0xc4,0x21,0x85,
  0x99,0x73,0x20,0x3e,0xc1,0x62,0xda,0xb9,0x26,0xb9,0x92,0x07,0x59,0x60,0x8e,0x46,
  0xb4,0x10,0x52,0x4e,0x9f,0x9a,0x02,0xe6,0x7d,0x8f,0xfa,0x40,0xf1,0xa2,0xa8,0x43,
  0xb8,0x92,0xe8,0x3a,0x03,0x47,0xbc,0x96,0x07,0x27,0xe6,0x46,0x92,0xac,0xd0,0xd2,
  0x23,0x30,0xea,0x74,0x05,0x48,0x43,0xf8,0x52,0x0e,0xe9,0x01,0x64,0x58,0xc5,0x74,
  0xe5,0xba,0x78,0x3a,0x48,0x15,0x12,0x0f,0xb8,0x44,0xf8,0xad,0x59,0x0a,0xb7,0xaa,
  0xce,0xf6,0xf9,0x62,0x04,0xb5,0x96,0x34,0xbd,0x12,0x23,0x19,0x24,0x6e,0x45,0x5f,
  0xea,0xa4,0x65,0x00,0x6a,0xb0,0xec,0xf2,0x61,0x2f,0xec,0x17,0x8d,0x85,0x43,0x6c,
  0x71,0x01,0x54,0x9f,0x79,0x6c,0x80,0xe7,0xb0,0xd8,0x04,0x4f,0x6c,0x47,0xc8,0x8e,
  0xec,0xf7,0xe9,0x1d,0x26,0x87,0x31,0x61,0xa1,0xc5,0x3b,0x4e,0xe6,0x54,0xd7,0x4f,
  0x19,0xcd,0x8d,0x64,0x91,0xd4,0x8a,0x16,0x33,0xf4,0x35,0xc4,0xec,0x81,0xe6,0xe3,
  0x85,0x46,0xf9,0x43,0xa0,0x49,0x9d,0x88,0xe8,0x9a,0x8b,0xac,0x72,0x1d,0xdc,0x46,
  0xa3,0x30,0xdf,0x41,0x8e,0x39,0xb5,0xc2,0x7e,0xd9,0x07,0x8b,0xc5,0x1b,0x14,0x60,
  0x80,0x1e,0xb8,0x28,0x80,0xac,0x42,0x7d,0x0d,0x7a,0x3a,0x6e,0x83,0x6a,0x2c,0xd4,
  0x96,0xd9,0x66,0xb1,0x95,0x00,0xf1,0x6a,0x84,0x4b,0xe8,0xdd,0x32,0x2e,0xc8,0x96,
  0xf9,0xd0,0x0e,0x9e,0x39,0x21,0x70,0x6b,0x19,0xde,0x83,0xbd,0x0d,0x5c,0x91,0xf5,
  0x89,0xf7,0xf2,0x29,0x40,0xb4,0x7b,0x55,0xe3,0x96,0x0e,0xe8,0xe2,0x90,0x4b,0x04,
  0x16,0xf2,0x40,0x25,0xa3,0x0e,0x94,0x36,0x43,0x54,0x78,0xee,0x0c,0x95,0x49,0x4b,
  0x7c,0x23,0xd6,0x73,0xec,0x44,0x8d,0xb4,0xbb,0x89,0xff,0x14,0xa0,0xb3,0x46,0x08,
  0x13,0xec,0x41,0xba,0xea,0x3c,0xf0,0x3b,0xdb,0x39,0x9a,0x78,0x61,0x7f,0x3c,0x68,
  0xdf,0xef,0x8a,0x29,0x37,0xec,0x80,0xfd,0xfa,0xe4,0xf1,0x31,0x66,0xd1,0x04,0x9a,
  0x41,0xf7,0xba,0xe5,0x11,0xa0,0xaf,0x68,0x00,0x21,0xb7,0x23,0xc7,0x24,0xd7,0x01,
  0xfb,0x59,0x6f,0xe8,0x9c,0x18,0x85,0x4c,0xb7,0x73,0x74,0xd2,0xd9,0x3c,0xa7,0xf1,
  0x2b,0x62,0x81,0x5f,0xe5,0x5b,0xf4,0x6d,0x08,0x3c,0x26,0x87,0x7f,0xe1,0xb4,0x69,
  0xab,0x5c,0xb2,0x38,0xd9,0xca,0xbf,0x42,0x29,0x9b,0x6e,0x39,0x71,0xb2,0x0e,0x3c,
  0x41,0x71,0x5b,0x7c,0xf6,0xf1,0x36,0x71,0xcc,0xaf,0xd1,0x90,0x07,0xe8,0x4c,0x78,
  0xcd,0xe9,0xd0,0xe2,0xcb,0x76,0x65,0x45,0x1d,0x07,0xe9,0x5e,0x38,0x78,0x25,0xd8,
  0xce,0x56,0x5b,0x5d,0x20,0x47,0xdb,0x1e,0xca,0x6a,0x31,0x5f,0x68,0x8b,0xf8,0x79,
  0x6b,0xa5,0x2d,0xdf,0x90,0x0d,0x4c,0x6f,0x92,0xbd,0x4b,0xb7,0x61,0x75,0xc2,0x20,
  0x97,0x2a,0x63,0xb1,0x3e,0x58,0x58,0x92,0x9a,0xe8,0x00,0x21,0x5d,0xe6,0x12,0x54,
  0x90,0x50,0x15,0x4f,0xf7,0xf7,0x8b,0xcf,0x37,0x56,0x31,0xd3,0xda,0xc1,0xc9,0xd6,
  0x8a,0x95,0x6a,0x53,0x9e,0x15,0xd4,0x4f,0x57,0xe2,0xb9,0xca,0xc2,0xaf,0xf2,0x02,
  0xce,0x88,0xa6,0x1c,0xa7,0xed,0x66,0x85,0x95,0xfc,0x4a,0x6f,0x99,0xe5,0x7e,0x05,
  0xe4,0xa4,0x66,0x7f,0x95,0x5f,0x16,0xe5,0x80,0x93,0xe9,0x51,0x3f,0x8c,0x19,0x9d,
  0x20,0x4c,0x36,0x99,0x94,0x66,0x24,0x28,0x70,0xeb,0xd0,0xd0,0xde,0xef,0x3b,0xae,
  0x5d,0xa0,0x6b,0x55,0x23,0x59,0x11,0xcb,0xdd,0x58,0x8f,0x6c,0x33,0x5d,0xc0,0xce,
  0xdd,0x8e,0x38,0x45,0x28,0x46,0x3d,0xc8,0x5f,0xf4,0xbd,0x6b,0xb5,0xbe,0xa2,0x6b,
  0x2b,0xdc,0x77,0x24,0xde,0x91,0xce,0x99,0xdb,0xd0,0x6c,0xf1,0x19,0xb5,0x17,0x6b,
  0x8f,0x2d,0x05,0xba,0x88,0x13,0x5a,0xf8,0x95,0xc8,0xcb,0x9a,0x9c,0xbd,0xeb,0x42,
  0xc4,0x3b,0xe8,0x74,0xb9,0x02,0x61,0x50,0x26,0x69,0xfb,0x27,0xcf,0x8c,0x9a,0x27,
  0xc4,0xc4,0xdd,0xbb,0x14,0x1a,0x8e,0x6a,0x28,0x56,0x42,0x16,0x5a,0x06,0x16,0xc9,
  0x5a,0x25,0x97,0x07,0x76,0x11,0xc7,0xc4,0x69,0x80,0x29,0x07,0x24,0xe9,0x0a,0x74,
  0x7d,0xe4,0x8d,0x0a,0xc4,0x65,0x89,0x45,0x73,0xdd,0xd6,0x10,0x67,0x81,0xa7,0x4f,
  0x11,0x9a,0x20,0xcb,0xd0,0xd5,0x01,0x0f,0xfb,0x9e,0x0d,0x88,0x3d,0x38,0x3c,0x39,
  0xbc,0x3c,0xcc,0xc3,0xf0,0xee,0xb2,0x80,0x25,0xdc,0x2c,0xef,0x75,0x31,0xa5,0x9e,
  0x3a,0x33,0xac,0x07,0x18,0x72,0x8b,0xaa,0x76,0x8a,0xac,0xa3,0x62,0xec,0x9a,0x82,
  0xd0,0x0c,0x35,0xd2,0x6c,0x03,0xeb,0xa6,0x50,0x59,0x8e,0x5f,0x97,0x58,0xd5,0x28,
  0x2d,0x4f,0x95,0x26,0x4b,0xcb,0xd7,0x66,0xe9,0x77,0x9e,0x0b,0x77,0x9f,0x0d,0xda,
  0x5a,0xe5,0x7f,0xfe,0x0f,0x18,0x7e,0x10,0x44,0xb5,0xf3,0xc9,0x9d,0x49,0xda,0xca,
  0x97,0xbe,0x32,0x37,0x6d,0xd9,0x4b,0x67,0x24,0xe3,0xc4,0xf7,0x74,0x3e,0xda,0x3d,
  0x39,0x61,0x32,0xd4,0x8f,0x71,0x0d,0x11,0x5a,0x14,0x7b,0xd4,0x2f,0x0e,0x48,0xbd,
  0xde,0x17,0x5b,0xd1,0x3b,0xd6,0x10,0x63,0x23,0x6d,0x8e,0xde,0x32,0xf0,0x4a,0x79,
  0xca,0xc6,0x0c,0x6d,0x40,0x88,0x11,0x30,0xff,0xa5,0xe4,0x99,0xb3,0x47,0x43,0x74,
  0x19,0x8a,0xe7,0x7f,0x24,0xee,0xd3,0xd6,0xf0,0x77,0x55,0xa7,0x24,0xa2,0x6c,0x56,
  0x48,0xee,0xf6,0x11,0xbc,0x67,0x17,0xa7,0x6c,0x24,0x4b,0x1d,0xf5,0x7c,0x57,0xba,
  0x4d,0xdb,0x01,0x24,0xc9,0x43,0xe8,0x9b,0xbf,0x09,0x28,0xba,0x8e,0x8d,0x6e,0x49,
  0xfc,0xf8,0x4e,0x13,0xa7,0x2e,0x25,0x4e,0xad,0x84,0x8a,0x98,0x1b,0xd2,0x9e,0x10,
  0x13,0xd1,0xff,0xfc,0xd1,0xc5,0x65,0x5e,0x2c,0x45,0x8b,0xfb,0xe6,0x83,0x26,0xb0,
  0x47,0x5e,0xce,0xc2,0x12,0xc6,0x17,0xf2,0x50,0x8c,0xb6,0xfd,0x89,0x9d,0x84,0x2b,
  0xc8,0x16,0xc0,0x30,0xa2,0x12,0x66,0x43,0x69,0xb2,0x2f,0x2f,0x1e,0x9d,0x61,0x20,
  0x08,0x70,0xe4,0x74,0x27,0x85,0xdb,0x28,0x1a,0xa6,0xdd,0x05,0xbe,0xc0,0x56,0xd7,
  0x69,0x31,0xe1,0xe2,0x72,0xe4,0x22,0x89,0x38,0x6c,0x13,0x1f,0xe6,0x03,0xcc,0x0c,
  0xea,0xca,0x48,0x58,0x51,0x84,0x1f,0x66,0xf2,0xfb,0x52,0xf6,0x42,0x7f,0x74,0x29,
  0xbb,0xc6,0x14,0x76,0xe6,0x12,0xff,0xec,0x65,0x7d,0x00,0x6f,0x6e,0xfa,0x49,0xdd,
  0x4c,0xa8,0x6d,0xf8,0x09,0x02,0xe1,0x77,0x2c,0x1c,0x6c,0x2e,0x03,0x39,0x06,0x05,
  0x6d,0xf3,0x0f,0xde,0x21,0x39,0x17,0x02,0xde,0x7a,0x99,0xde,0x2e,0x1c,0x52,0x60,
  0x76,0x46,0x55,0x75,0x0b,0xe5,0xd4,0xc6,0x3b,0xd8,0xfb,0x59,0x10,0xc4,0xed,0x91,
  0x53,0xeb,0x53,0xd6,0x1d,0x3c,0xc6,0xf5,0x56,0xed,0x4a,0x42,0x84,0x14,0x71,0x59,
  0x19,0x3f,0x45,0x51,0x75,0x3c,0xad,0x0b,0x1f,0x5a,0xf1,0x5b,0x1c,0x11,0xed,0xb4,
  0x0e,0x82,0x56,0x74,0x74,0x9b,0x06,0x54,0x54,0x95,0x55,0xef,0xa1,0x18,0x7d,0x88,
  0xcb,0x75,0xa8,0x0d,0x55,0x4e,0xf4,0x91,0xc6,0xd1,0xc1,0x36,0x54,0xa9,0x47,0xed,
  0x57,0xbc,0x13,0x96,0x5f,0xf3,0x49,0x50,0xc0,0x82,0x45,0x69,0x06,0x9a,0xae,0x78,
  0xb4,0x23,0xfa,0xf7,0xec,0xcc,0x03,0x67,0x05,0xa4,0x77,0xe8,0x49,0x89,0xf2,0xeb,
  0xdf,0x44,0x57,0xb4,0x5a,0x21,0x73,0x39,0x1e,0x08,0x07,0x25,0x00,0x2f,0xb9,0x9b,
  0x38,0xd5,0xa0,0x29,0x85,0xb7,0xb1,0x62,0xb8,0xb0,0xae,0x44,0x1c,0x04,0x3e,0xe3,
  0xd5,0x94,0xf2,0x1e,0xd8,0x6a,0x30,0x73,0xb3,0xe7,0x4f,0x2a,0x15,0x08,0x33,0x0b,
  0xcc,0x3a,0x76,0xbb,0xa4,0xeb,0x18,0xb1,0xd0,0x2e,0x46,0x55,0xd4,0xb5,0x0c,0x5e,
  0xc7,0x69,0x7f,0x26,0xaf,0xe2,0xd4,0xf6,0x1c,0x99,0xda,0x44,0xd3,0x17,0xfa,0x1c,
  0xbe,0x78,0xc7,0x39,0x9b,0x11,0x94,0xd6,0x0f,0x00,0x21,0x31,0xa7,0xea,0x13,0xfd,
  0xc8,0x7f,0x14,0x1f,0xff,0xb8,0xd3,0x54,0x18,0xb7,0x6c,0x6b,0xd2,0x48,0xe4,0x6b,
  0x98,0x3d,0xa3,0xd5,0x3d,0xe5,0xb8,0x2d,0x54,0x26,0xe6,0xbc,0xcf,0xaa,0x80,0xcd,
  0x8a,0x76,0xa6,0x40,0x85,0xfc,0x17,0x39,0x0a,0x11,0xaf,0x10,0x44,0xb2,0x5c,0x2c,
  0x15,0x24,0xd9,0x3a,0x5a,0x57,0xb8,0x2f,0xfa,0x49,0xc6,0xb8,0xec,0x32,0x46,0xfc,
  0x54,0xab,0xf4,0x5e,0x3d,0x2c,0xbe,0x81,0x53,0xa9,0x37,0x63,0x2d,0x43,0x80,0x47,
  0xee,0x89,0x00,0x26,0xb7,0x8a,0xc9,0x1e,0x20,0x07,0x7e,0xff,0x47,0x8d,0x05,0x2e,
  0x2e,0x77,0x1f,0x5f,0x1e,0x1e,0x28,0x23,0x29,0xc2,0x09,0xae,0xeb,0x16,0x05,0x8f,
  0x7e,0xff,0x67,0xa3,0xfc,0xa3,0xf3,0x73,0xcc,0x13,0x37,0xcf,0xc8,0x89,0xab,0xcc,
  0x3d,0x92,0xa6,0x8d,0x45,0x8d,0x24,0x1a,0x87,0xae,0x85,0xc4,0x76,0xaf,0x99,0x54,
  0xd7,0xd7,0x15,0x95,0xfa,0x40,0x3e,0x58,0x8c,0x57,0x74,0xde,0xe8,0x7a,0xf3,0x38,
  0x4c,0xdd,0x98,0x1e,0x6f,0x56,0xfd,0x4c,0x74,0xd1,0xb4,0x9d,0x11,0x74,0xc4,0x84,
  0xdb,0xec,0xb3,0xcf,0xc4,0x18,0xa3,0x0d,0xae,0xf4,0xa4,0xe4,0xb4,0x00,0x90,0xda,
  0xd9,0x44,0x5b,0x43,0xc4,0x82,0x25,0x6d,0x70,0xd3,0x79,0x47,0x2c,0xc1,0xb7,0xf4,
  0xea,0x66,0x1e,0x0a,0x23,0x19,0x86,0xb1,0x77,0x35,0xbb,0xb5,0xe3,0x33,0xb9,0x15,
  0x65,0x26,0x4c,0x91,0x93,0x2f,0x1f,0x2f,0xbc,0x21,0xca,0x8a,0x84,0xb8,0xcc,0x60,
  0x6b,0x62,0x4f,0xaa,0xcc,0x89,0x17,0xd9,0x31,0xa5,0xd4,0x91,0xd7,0x0e,0xf8,0xad,
  0x20,0xde,0xf1,0x58,0xfd,0xe2,0x79,0x24,0x70,0x51,0x29,0x60,0x47,0x87,0x97,0x6c,
  0xa5,0x23,0xae,0xe1,0xbd,0x7f,0x65,0xf9,0xdb,0x5f,0x7f,0x81,0x33,0xee,0x9b,0x28,
  0x4b,0xab,0xeb,0xbc,0x16,0x19,0x00,0x3c,0xbc,0xdf,0x8a,0xae,0x27,0x0c,0x46,0x3e,
  0x07,0xed,0xdd,0x15,0x67,0xbf,0x52,0xc9,0x5d,0x07,0x23,0x18,0x3d,0x7b,0x34,0xc4,
  0xf3,0x79,0xdf,0x8d,0x31,0xd3,0x2d,0x1e,0xee,0x02,0xd8,0x0e,0xae,0x03,0xc1,0xd4,
  0x73,0x30,0x6b,0x38,0x59,0x9d,0x80,0xa0,0x6b,0xdf,0x09,0x39,0x9d,0x06,0x3b,0x85,
  0x29,0xc0,0x30,0x3b,0x2e,0xde,0x85,0xde,0xf6,0x30,0x64,0xca,0x05,0x1b,0xb1,0xe3,
  0x03,0x4a,0xe1,0x20,0x8e,0x0b,0x53,0x35,0x05,0x8e,0xd2,0xd8,0x04,0x65,0x79,0x90,
  0x7c,0x7f,0xf7,0xf4,0xe5,0xd3,0xdd,0xc7,0x2f,0x4f,0x77,0xcf,0xd1,0x08,0x01,0x5c,
  0xca,0xab,0x7a,0x9b,0xc6,0x85,0xba,0x2c,0xba,0x0c,0xb6,0xa9,0x5d,0xd8,0xca,0xf0,
  0xbe,0xd1,0xa6,0x71,0x31,0x28,0x13,0xd7,0x5a,0x36,0xf5,0xdb,0x27,0x11,0xa8,0xb8,
  0x71,0xb1,0x99,0xba,0x5e,0x91,0xe1,0xe5,0x6b,0x4d,0xbc,0x60,0x4d,0xfe,0x3e,0x6a,
  0x6a,0xb7,0xad,0x31,0x79,0xb9,0x59,0x33,0xbe,0xc9,0x0c,0xd9,0x7e,0xf7,0x70,0xbf,
  0x89,0xf7,0xc6,0x50,0x95,0xc3,0xfd,0x5a,0x53,0x5e,0x96,0xc4,0xf0,0x72,0xa1,0xa6,
  0x76,0x0b,0x10,0xa3,0x7b,0x6b,0x9a,0xfa,0x1d,0x33,0x54,0xff,0x08,0xeb,0xf7,0x3a,
  0x54,0xe0,0x68,0xff,0xa8,0xa9,0x5d,0xc9,0xc1,0x02,0xfc,0x68,0x5c,0x42,0x81,0x55,
  0xf6,0xce,0xe1,0x2d,0xa5,0xfe,0x67,0x98,0xca,0xbe,0x29,0xf2,0xd5,0x33,0x4a,0xc3,
  0xde,0x94,0xb9,0xd6,0x19,0x25,0x10,0x6f,0xc6,0xd9,0xc2,0xb1,0x22,0x25,0xc2,0x6e,
  0xaa,0xac,0xd7,0x0c,0xf3,0x39,0x37,0x45,0xd2,0x66,0x46,0xb9,0x88,0x9b,0x71,0xe2,
  0xe1,0x25,0xe3,0x4c,0xbd,0xca,0x89,0x09,0xc6,0x97,0xb6,0xc6,0x27,0xa8,0x06,0xb4,
  0x94,0x81,0x6e,0x8d,0x7e,0x2f,0xa0,0x24,0x1d,0xce,0x82,0xbf,0x75,0xc5,0xa1,0xf3,
  0xaa,0x58,0xea,0x13,0x95,0x51,0x61,0x28,0x5d,0x11,0xe9,0x28,0x6c,0xc8,0x58,0xbb,
  0x4c,0x46,0x08,0xa2,0x5c,0xb8,0x5a,0x77,0x30,0xef,0xef,0x42,0x8a,0x0e,0x0b,0x1a,
  0x2a,0xae,0x66,0xa8,0x38,0xfc,0x7c,0x1f,0xff,0xa0,0x3e,0xe1,0x8f,0x94,0xee,0xba,
  0xc5,0x75,0x54,0x9f,0x3c,0x74,0xa9,0x0f,0x28,0xeb,0x31,0x86,0x4d,0x80,0xdd,0x55,
  0x35,0xf2,0xc4,0x4f,0x1f,0xbe,0x41,0xab,0x52,0xf7,0xab,0xa9,0x6c,0x5a,0x65,0xb4,
  0xa2,0x28,0x41,0x86,0xbe,0x99,0x52,0x27,0x23,0x66,0x97,0xcc,0x87,0x64,0xf8,0xaa,
  0x40,0xce,0xc4,0xa6,0xdd,0x77,0x59,0x48,0x8f,0x6e,0xc4,0x96,0xdb,0x78,0xb6,0xd9,
  0x3d,0xbb,0x1c,0x4f,0xd4,0x7b,0xb5,0xd6,0x8c,0xda,0x99,0xf7,0x69,0x8b,0x7d,0x40,
  0x31,0x88,0x79,0xdb,0x92,0xb4,0xdb,0x9d,0x45,0x4e,0x58,0xec,0x81,0x12,0x09,0xd4,
  0xfe,0xac,0x1e,0x4c,0xb9,0x1b,0x9a,0xc5,0x20,0xe6,0xb5,0x2f,0xee,0x2b,0xd6,0x77,
  0x31,0x41,0xfb,0xb1,0x04,0x9a,0x83,0x81,0xd4,0x6d,0xc7,0xf1,0x8e,0xaa,0x08,0xc4,
  0xdc,0x1e,0xc8,0x3b,0x78,0x55,0x1f,0x44,0x0f,0x94,0xb8,0x13,0x28,0xb8,0xd3,0x0d,
  0xbe,0xaa,0x07,0x0a,0xc4,0xbc,0x0e,0x08,0x59,0xaa,0x33,0x01,0x54,0x36,0xe4,0xea,
  0x1c,0x08,0x28,0x67,0x35,0xe3,0x95,0x91,0xe5,0x00,0x66,0xdc,0x75,0x7b,0x81,0x8a,
  0x47,0x7a,0xcd,0xa8,0x22,0x49,0xcf,0x79,0x1d,0x17,0xc2,0xdc,0xec,0xb8,0x14,0xec,
  0x73,0x1b,0x3e,0xdc,0xcf,0xea,0x31,0xef,0x2c,0x50,0xb1,0x96,0xd1,0x63,0xd0,0x17,
  0xf3,0x7a,0x2b,0xae,0x9d,0x4b,0x70,0x9a,0xd2,0x2d,0x73,0x39,0x3d,0x75,0x69,0x5d,
  0xc4,0x69,0x0a,0xc4,0xfc,0xf6,0xe9,0xfe,0xb4,0xa8,0x03,0xa2,0xae,0x54,0x64,0xad,
  0x39,0xb1,0xe7,0x8c,0xdb,0xd7,0xd2,0x30,0xe6,0xa1,0xee,0x28,0x13,0xe7,0xbd,0xce,
  0xdc,0x9e,0x8b,0x7b,0xb0,0xcc,0x9e,0x4b,0x0d,0xdb,0x62,0x73,0x7b,0x9e,0xba,0x45,
  0x2b,0x05,0x63,0x4e,0xfb,0xd4,0xef,0x98,0x70,0x54,0x57,0xd3,0xe8,0xf3,0xc6,0x0d,
  0xba,0x3e,0x63,0xdc,0xa0,0xfc,0xe7,0x55,0x7c,0x96,0x59,0xf1,0x7a,0x7e,0x45,0xb4,
  0x22,0xd2,0x4c,0x8a,0x56,0xc5,0xbc,0x9a,0x68,0x71,0xa4,0x6b,0x4a,0x0b,0x64,0x5e,
  0x65,0xb2,0x4d,0xb4,0xda,0xa2,0x32,0x99,0x2a,0xf3,0xaa,0x82,0x19,0x93,0x31,0x54,
  0xb0,0x6b,0xe6,0x55,0x44,0x9b,0x27,0xdd,0x61,0x65,0x03,0xe9,0x5b,0xed,0xd4,0x66,
  0xc8,0x29,0x3b,0x19,0xa7,0x93,0x3f,0xce,0x1d,0x1f,0x6f,0xe6,0x93,0xc0,0xe6,0x2e,
  0x2b,0x66,0x27,0x9e,0x4f,0x83,0xd0,0x37,0x1c,0x92,0xc5,0xb1,0xe8,0x5e,0x43,0xdd,
  0x04,0x22,0xb0,0xf8,0xa2,0x95,0xda,0x32,0x96,0xde,0x0f,0xa8,0x25,0x0d,0xcf,0x3e,
  0x03,0x0b,0x26,0x10,0x46,0xfd,0x3b,0x09,0xe7,0x07,0xcc,0xa2,0xae,0x85,0x9b,0x49,
  0x27,0x2a,0x61,0x49,0x90,0x58,0xe6,0x93,0xa7,0x74,0xe4,0x47,0x74,0x03,0x62,0x73,
  0xa0,0x59,0x59,0x56,0x9a,0x19,0x7e,0xc6,0x4a,0x12,0x1f,0x94,0xbe,0xc2,0xdf,0x86,
  0xfa,0x81,0x17,0x84,0x1e,0xd0,0x0b,0xcd,0xea,0xb2,0xd2,0x0e,0xf0,0x53,0x0a,0x7b,
  0xf8,0x0e,0x42,0x08,0x3f,0x81,0x18,0xa6,0x07,0x21,0x11,0xc5,0x7b,0x21,0x9c,0x9a,
  0xf5,0x8a,0x82,0xd2,0xa3,0xa2,0x72,0xee,0x43,0x19,0x6d,0x2a,0xc3,0x13,0xcc,0x4b,
  0xf8,0x13,0x26,0x19,0x14,0xf2,0xad,0xeb,0x97,0xbd,0x81,0x05,0xbf,0x70,0xee,0xc0,
  0x5f,0x22,0xd2,0x27,0x66,0x03,0x94,0x22,0xd6,0x86,0xbf,0x81,0x4f,0xe1,0xa3,0x62,
  0xba,0x66,0xe5,0x6d,0x8c,0x86,0x00,0xb7,0xa6,0x00,0x0e,0x64,0xe8,0x13,0xe8,0xe6,
  0x3b,0x3c,0x28,0x28,0xec,0x14,0xcb,0x03,0x6b,0x54,0x28,0xbc,0x78,0xbd,0x7c,0xf5,
  0x6d,0x51,0x45,0xd2,0xa7,0x59,0xda,0xaf,0x0d,0x1b,0xfb,0x2a,0x41,0x60,0x11,0x25,
  0xd7,0x32,0xcf,0x7c,0x67,0xde,0xfd,0x80,0xcb,0x6a,0x98,0xd7,0x1f,0x08,0x68,0xc7,
  0xa9,0xdd,0xa9,0x7f,0xe5,0xd1,0x38,0xe8,0x17,0xb2,0x9a,0x95,0x30,0xa8,0xd1,0x6a,
  0x2d,0x9f,0x68,0x92,0xda,0x9b,0x03,0xc1,0x48,0xc1,0x4f,0x70,0x2a,0x99,0x60,0xee,
  0x32,0xff,0xaa,0xb5,0x99,0x35,0xa6,0x4e,0xba,0x39,0xf5,0x02,0x71,0xa9,0x80,0x6a,
  0xa5,0x32,0xbb,0x91,0xd4,0x0d,0x04,0xaa,0xca,0xb9,0xef,0x0d,0x9c,0x80,0x97,0x61,
  0xf6,0x14,0x08,0x39,0x51,0x76,0xa2,0xed,0x9d,0x2c,0xbb,0x3e,0x15,0xf4,0xdc,0xf7,
  0x5c,0x8c,0x46,0x51,0x38,0x21,0x50,0x57,0xec,0xfd,0xd3,0x66,0x32,0xc5,0xc0,0x90,
  0xec,0x16,0x2f,0x38,0xc6,0x09,0x6b,0xcc,0x52,0x3d,0x73,0x29,0x1d,0xb9,0xb6,0xd4,
  0x56,0xdb,0x88,0xb5,0x65,0x8a,0xf9,0x95,0xa0,0x54,0x56,0x2a,0x5c,0xd1,0x9f,0x42,
  0x1e,0x93,0xe7,0xc8,0xef,0xb4,0xec,0x30,0xb5,0x80,0x08,0xe7,0xec,0x79,0x5e,0xb8,
  0x94,0x99,0x69,0x76,0xc9,0xc8,0x46,0xbb,0xa4,0xed,0x96,0x6e,0x2d,0xc1,0x54,0x52,
  0xe1,0xd4,0x42,0x5c,0x6c,0x99,0x35,0x2a,0x94,0xc1,0x63,0x6b,0x45,0xa5,0xc5,0xde,
  0x5a,0xc1,0x5e,0xe0,0xdf,0xfd,0x70,0xe0,0xee,0x2c,0xfd,0x7f,0x74,0xf4,0xdc,0x8f,
  0xbe,0xce,0x00,0x00
};


// ============================================================
//  CAMERA INIT
//  The OV2640 on AI-Thinker / HW-381 boards cannot have its
//  frame-size changed via set_framesize() while the DMA/I2S
//  capture engine is running - doing so causes FB-OVF errors.
//  The ONLY safe approach is full deinit ? reinit with the new
//  config.  initCameraMode() encapsulates that.
// ============================================================

// Build camera_config_t for a given mode
static camera_config_t buildCamConfig(framesize_t fs, int quality, int fbCount) {
  camera_config_t cfg;
  cfg.ledc_channel = LEDC_CHANNEL_0;
  cfg.ledc_timer   = LEDC_TIMER_0;
  cfg.pin_d0  = Y2_GPIO_NUM; cfg.pin_d1  = Y3_GPIO_NUM;
  cfg.pin_d2  = Y4_GPIO_NUM; cfg.pin_d3  = Y5_GPIO_NUM;
  cfg.pin_d4  = Y6_GPIO_NUM; cfg.pin_d5  = Y7_GPIO_NUM;
  cfg.pin_d6  = Y8_GPIO_NUM; cfg.pin_d7  = Y9_GPIO_NUM;
  cfg.pin_xclk     = XCLK_GPIO_NUM;
  cfg.pin_pclk     = PCLK_GPIO_NUM;
  cfg.pin_vsync    = VSYNC_GPIO_NUM;
  cfg.pin_href     = HREF_GPIO_NUM;
  cfg.pin_sccb_sda = SIOD_GPIO_NUM;
  cfg.pin_sccb_scl = SIOC_GPIO_NUM;
  cfg.pin_pwdn     = PWDN_GPIO_NUM;
  cfg.pin_reset    = RESET_GPIO_NUM;
  cfg.xclk_freq_hz = 20000000;
  cfg.pixel_format = PIXFORMAT_JPEG;
  cfg.frame_size   = fs;
  cfg.jpeg_quality = quality;
  cfg.fb_count     = fbCount;
  if (psramFound()) {
    cfg.fb_location = CAMERA_FB_IN_PSRAM;
    // LATEST mode: newest frame always available, older ones auto-discarded
    // - prevents FB-OVF during streaming
    cfg.grab_mode = (fbCount > 1) ? CAMERA_GRAB_LATEST : CAMERA_GRAB_WHEN_EMPTY;
  } else {
    cfg.fb_location = CAMERA_FB_IN_DRAM;
    cfg.grab_mode   = CAMERA_GRAB_WHEN_EMPTY;
  }
  return cfg;
}

// Full deinit + reinit - the only safe way to change resolution
bool initCameraMode(framesize_t fs, int quality, int fbCount) {
  esp_camera_deinit();
  delay(100);   // let DMA/I2S engine fully stop
  camera_config_t cfg = buildCamConfig(fs, quality, fbCount);
  esp_err_t err = esp_camera_init(&cfg);
  if (err != ESP_OK) {
    Serial.printf("[CAM] Reinit FAILED 0x%x\n", err);
    return false;
  }
  Serial.printf("[CAM] Mode: fs=%d q=%d fb=%d\n", (int)fs, quality, fbCount);
  return true;
}

// First-time init on boot (stream mode: VGA, 2 buffers for GRAB_LATEST)
bool initCamera() {
  framesize_t fs = psramFound() ? (framesize_t)streamFrameSize : FRAMESIZE_VGA;
  int quality    = psramFound() ? 10 : 12;
  int fbCount    = psramFound() ? 2  : 1;
  camera_config_t cfg = buildCamConfig(fs, quality, fbCount);
  esp_err_t err = esp_camera_init(&cfg);
  if (err != ESP_OK) { Serial.printf("📷 FAILED 0x%x\n", err); return false; }
  Serial.printf("[CAM] Boot: VGA MJPEG PSRAM=%d\n", (int)psramFound());
  return true;
}


// ============================================================
//  CAMERA SETTINGS HELPERS
// ============================================================

bool initSD() {
  if (!SD_MMC.begin("/sdcard", true)) { Serial.println("💾 Failed"); return false; }
  if (SD_MMC.cardType() == CARD_NONE) { Serial.println("💾 No card"); return false; }
  Serial.printf("[SD] Ready %.1f GB\n",
    (float)SD_MMC.totalBytes() / (1024.0*1024*1024));
  return true;
}

// ============================================================
//  HELPERS
// ============================================================
String getTimestamp() {
  struct tm ti;
  if (!getLocalTime(&ti)) {
    char buf[20]; snprintf(buf, sizeof(buf), "notime_%lu", millis()/1000);
    return String(buf);
  }
  char buf[22]; strftime(buf, sizeof(buf), "%Y-%m-%d_%H-%M-%S", &ti);
  return String(buf);
}

String getResLabel(int fs) {
  switch(fs) {
    case 1:  return "QQVGA";
    case 5:  return "QVGA";
    case 8:  return "VGA";
    case 9:  return "SVGA";
    case 10: return "XGA";
    case 11: return "HD";
    case 12: return "SXGA";
    case 13: return "UXGA";
    default: return "VGA";
  }
}

String getUptime() {
  unsigned long elapsed = (millis() - bootMs) / 1000;
  unsigned long h = elapsed / 3600;
  unsigned long m = (elapsed % 3600) / 60;
  char buf[16];
  snprintf(buf, sizeof(buf), "%luh %lum", h, m);
  return String(buf);
}

void applyStreamResolution() {
  int fbCount = psramFound() ? 2 : 1;
  initCameraMode((framesize_t)streamFrameSize, STREAM_JPEG_QUALITY, fbCount);
  Serial.printf("[CAM] Stream mode: res=%d(%s) fps=%d\n",
    streamFrameSize, getResLabel(streamFrameSize).c_str(), streamFps);
}

// Delete all files in /photos and /videos
void deleteAllSD() {
  if(sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  auto rmDir = [](const char* dir) -> int {
    int count = 0;
    File root = SD_MMC.open(dir);
    if (!root || !root.isDirectory()) return 0;
    File f = root.openNextFile();
    while (f) {
      if (!f.isDirectory()) {
        String path = String(dir) + "/" + String(f.name());
        f.close();
        SD_MMC.remove(path.c_str());
        count++;
        f = root.openNextFile();
      } else {
        f.close();  // explicitly close directory handles before moving to next entry
        f = root.openNextFile();
      }
    }
    root.close();
    return count;
  };
  int n = rmDir("/photos") + rmDir("/videos");
  if(sdMutex) xSemaphoreGive(sdMutex);
  photoCount = 0; videoCount = 0;
  Serial.printf("[SD] Deleted all: %d files\n", n);
}

int countPhotos() {
  int c=0; File r=SD_MMC.open("/photos");
  if (r&&r.isDirectory()){File f=r.openNextFile();while(f){if(!f.isDirectory())c++;f=r.openNextFile();}}
  if(r) r.close();
  return c;
}
int countVideos() {
  int c=0; File r=SD_MMC.open("/videos");
  if (r&&r.isDirectory()){File f=r.openNextFile();while(f){if(!f.isDirectory())c++;f=r.openNextFile();}}
  if(r) r.close();
  return c;
}

// ============================================================
//  ARM / DISARM  - resets warm-up and consecutive counters
// ============================================================
void armMotion() {
  motionArmed       = true;
  prevFrameReady    = false;   // force fresh baseline on first frame
  mdWarmupCount     = 0;
  mdWarmedUp        = false;
  mdConsecutive     = 0;
  Serial.println("[MD] ARMED - warm-up started");
}

void disarmMotion() {
  motionArmed    = false;
  mdWarmedUp     = false;
  mdConsecutive  = 0;
  Serial.println("[MD] DISARMED");
}

// ============================================================
//  TELEGRAM HELPERS
// ============================================================
// --- Non-blocking Telegram enqueue helpers ----------------------
void tgEnqueue(const String& msg) {
  if (!tgQueue || !telegramEnabled) return;
  TgJob job; job.type = TG_TEXT;
  strlcpy(job.text, msg.c_str(), sizeof(job.text));
  xQueueSend(tgQueue, &job, 0);
}
void tgEnqueuePhoto(const String& path, const String& cap) {
  if (!tgQueue || !telegramEnabled) return;
  TgJob job; job.type = TG_PHOTO;
  strlcpy(job.path,    path.c_str(), sizeof(job.path));
  strlcpy(job.caption, cap.c_str(),  sizeof(job.caption));
  xQueueSend(tgQueue, &job, 0);
}
void tgEnqueueVideo(const String& path, const String& cap) {
  if (!tgQueue || !telegramEnabled) return;
  TgJob job; job.type = TG_VIDEO;
  strlcpy(job.path,    path.c_str(), sizeof(job.path));
  strlcpy(job.caption, cap.c_str(),  sizeof(job.caption));
  xQueueSend(tgQueue, &job, 0);
}
// Legacy alias: all existing tgSend() call-sites compile unchanged
inline void tgSend(const String& msg) { tgEnqueue(msg); }

// --- Telegram worker - runs forever on Core 0 -------------------
// sendPhotoToTelegram / sendVideoToTelegram called ONLY from here.
void telegramTask(void*) {
  unsigned long lastPollMs = 0;
  for (;;) {
    // Use a 500ms queue timeout so we can also poll for incoming Telegram
    // commands on Core 0 without blocking Core 1's main loop at all.
    TgJob job;
    if (xQueueReceive(tgQueue, &job, pdMS_TO_TICKS(500)) == pdTRUE) {
      if (!bot || !telegramEnabled) { vTaskDelay(pdMS_TO_TICKS(10)); continue; }
      xSemaphoreTake(tgBusySem, portMAX_DELAY);
      switch (job.type) {
        case TG_TEXT:  bot->sendMessage(cfgChatID.c_str(), String(job.text), ""); break;
        case TG_PHOTO: sendPhotoToTelegram(String(job.path), String(job.caption)); break;
        case TG_VIDEO:
          vTaskDelay(pdMS_TO_TICKS(3000));
          sendVideoToTelegram(String(job.path), String(job.caption));
          break;
      }
      xSemaphoreGive(tgBusySem);
      vTaskDelay(pdMS_TO_TICKS(200));
    }

    // Poll for incoming Telegram commands here on Core 0 every 2 seconds.
    // Previously this ran in loop() on Core 1, blocking it with a full
    // HTTPS round-trip every 2s and starving the stream task.
    if (!bot || !telegramEnabled) continue;
    unsigned long now = millis();
    if (now - lastPollMs < 2000) continue;
    lastPollMs = now;
    xSemaphoreTake(tgBusySem, portMAX_DELAY);
    int n = bot->getUpdates(bot->last_message_received + 1);
    xSemaphoreGive(tgBusySem);
    while (n) {
      for (int i = 0; i < n; i++) {
        String text = bot->messages[i].text;
        if (bot->messages[i].chat_id != cfgChatID) continue;
        Serial.println("[TG] " + text);
        if (text == "/help" || text == "/start") {
          bot->sendMessage(cfgChatID.c_str(),
            "\xF0\x9F\x93\xB7 *ESP32-CAM Surveillance - Help Menu*\n\n"
            "\xF0\x9F\x93\xB8 /photo - Capture hi-res photo (no flash)\n"
            "\xE2\x9A\xA1 /photoflash - Capture hi-res photo WITH flash\n"
            "\xF0\x9F\x8E\xA5 /video - Record 10s AVI video\n"
            "\xF0\x9F\x8E\xAC /record30 - Record 30s AVI video\n"
            "\xF0\x9F\x93\x8A /status - Full system status\n"
            "\xF0\x9F\x94\x92 /arm - Arm motion detection\n"
            "\xF0\x9F\x94\x93 /disarm - Disarm motion detection\n"
            "\xF0\x9F\x92\xBE /storage - SD card storage info\n"
            "\xF0\x9F\x94\x84 /restart - Restart the ESP32\n"
            "\xE2\x9D\x93 /help - Show this menu\n\n"
            "\xF0\x9F\x92\xA1 _Dashboard: http://" + WiFi.localIP().toString() + "_", "Markdown");
        }
        else if (text == "/photo") {
          tgSend("\xF0\x9F\x93\xB8 Capturing hi-res photo (no flash)...");
          pendingJob.flash = false; pendingJob.type = JOB_PHOTO;
        }
        else if (text == "/photoflash") {
          tgSend("\xE2\x9A\xA1 Capturing hi-res photo WITH flash...");
          pendingJob.flash = true; pendingJob.type = JOB_PHOTO;
        }
        else if (text == "/video")    { pendingJob.recSecs = 10; pendingJob.type = JOB_RECORD; }
        else if (text == "/record30") { pendingJob.recSecs = 30; pendingJob.type = JOB_RECORD; }
        else if (text == "/status") {
          float temp = temperatureRead();
          unsigned long lm = (millis() - lastMotionMs) / 1000;
          bot->sendMessage(cfgChatID.c_str(),
            "\xF0\x9F\x8C\x90 *Network Status:*\n"
            "\xF0\x9F\x93\xB6 WiFi: Connected \xE2\x9C\x85\n"
            "\xF0\x9F\x93\xB1 IP: " + WiFi.localIP().toString() + "\n"
            "\xF0\x9F\x93\xA1 RSSI: " + String(WiFi.RSSI()) + " dBm\n"
            "\xF0\x9F\x8C\xA1 Temp: " + String(temp, 1) + " degC\n\n"
            "\xF0\x9F\x93\xB7 *Camera:*\n"
            "\xF0\x9F\x8E\xA5 Stream: " + getResLabel(streamFrameSize) + " @" + String(streamFps) + "fps\n"
            "\xF0\x9F\x93\xB8 Photos: " + String(photoCount) + "\n"
            "\xF0\x9F\x94\xB4 Recording: " + (aviRecording ? "ACTIVE" : "IDLE") + "\n\n"
            "\xF0\x9F\x8F\x83 *Motion Detection:*\n"
            "\xF0\x9F\x94\x8D Status: " + (motionArmed ? "ARMED \xF0\x9F\x9F\xA2" : "DISARMED \xF0\x9F\x94\xB4") + "\n"
            "\xF0\x9F\x8E\x9A Sensitivity: " + String(motionSensitivity) + "\n"
            "\xE2\x8F\xB1 Cooldown: " + String(motionCooldownS) + "s\n"
            "\xF0\x9F\x95\x90 Last alert: " + String(lm) + "s ago", "Markdown");
        }
        else if (text == "/arm")    { armMotion();    tgSend("\xF0\x9F\x94\x92 Motion *ARMED* \xF0\x9F\x9F\xA2"); }
        else if (text == "/disarm") { disarmMotion(); tgSend("\xF0\x9F\x94\x93 Motion *DISARMED*"); }
        else if (text == "/storage") {
          uint64_t tot = SD_MMC.totalBytes(), used = SD_MMC.usedBytes();
          String sdt = "Unknown";
          switch (SD_MMC.cardType()) {
            case CARD_MMC:  sdt = "MMC";        break;
            case CARD_SD:   sdt = "SDSC";       break;
            case CARD_SDHC: sdt = "SDHC/SDXC"; break;
            default: break;
          }
          bot->sendMessage(cfgChatID.c_str(),
            "\xF0\x9F\x92\xBE *SD Card:*\n"
            "Type: " + sdt + "\n"
            "Total: " + String((uint32_t)(tot / (1024*1024))) + " MB\n"
            "Used: "  + String((uint32_t)(used / (1024*1024))) + " MB\n"
            "Free: "  + String((uint32_t)((tot-used) / (1024*1024))) + " MB\n"
            "Photos: " + String(photoCount) + "  Videos: " + String(videoCount), "Markdown");
        }
        else if (text == "/restart") {
          tgSend("\xF0\x9F\x94\x84 Restarting now...");
          vTaskDelay(pdMS_TO_TICKS(500)); ESP.restart();
        }
        else { tgSend("\xE2\x9D\x93 Unknown command. Send /help for menu."); }
      }
      xSemaphoreTake(tgBusySem, portMAX_DELAY);
      n = bot->getUpdates(bot->last_message_received + 1);
      xSemaphoreGive(tgBusySem);
    }
  }
}


void sendPhotoToTelegram(const String& filePath, const String& caption) {
  if (!telegramEnabled) return;

  // Step 1: get file size under mutex (fast - just a stat)
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File fSize = SD_MMC.open(filePath.c_str(), FILE_READ);
  size_t sz = fSize ? fSize.size() : 0;
  if (fSize) fSize.close();
  if (sdMutex) xSemaphoreGive(sdMutex);
  if (sz == 0) { Serial.println("[TG] Photo: file not found or empty"); return; }

  // Step 2: TLS connect (1-3s) - NO mutex held, main loop runs freely
  // Retry up to 3 times with 2s delay - camera reinit can briefly disturb WiFi stack
  WiFiClientSecure cl; cl.setCACert(TELEGRAM_CERTIFICATE_ROOT);
  bool tlsOk = false;
  for (int attempt = 1; attempt <= 3; attempt++) {
    if (cl.connect("api.telegram.org", 443, 15000)) { tlsOk = true; break; }
    Serial.printf("[TG] Photo: TLS connect failed (attempt %d/3)\n", attempt);
    if (attempt < 3) { cl.stop(); delay(2000); }
  }
  if (!tlsOk) { Serial.println("[TG] Photo: all TLS attempts failed"); return; }


  // Step 3: send HTTP headers
  const String bd = "ESP32PB123";
  String head =
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"chat_id\"\r\n\r\n"+cfgChatID+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"caption\"\r\n\r\n"+caption+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"photo\"; filename=\"p.jpg\"\r\n"
    "Content-Type: image/jpeg\r\n\r\n";
  String tail = "\r\n--"+bd+"--\r\n";
  cl.printf("POST /bot%s/sendPhoto HTTP/1.1\r\nHost: api.telegram.org\r\n"
            "Content-Type: multipart/form-data; boundary=%s\r\n"
            "Content-Length: %u\r\nConnection: close\r\n\r\n",
            cfgBotToken.c_str(), bd.c_str(), (unsigned)(head.length()+sz+tail.length()));
  cl.print(head);

  // Step 4: stream file bytes - take mutex only for the SD read portion
  // OPT: Use 8KB chunks instead of 1KB to reduce mutex lock/unlock cycles
  // from ~200 to ~25 for a typical 200KB photo. SD bus is idle during cl.write()
  // so the tight acquire-read-release-write-acquire loop was pure overhead.
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File f = SD_MMC.open(filePath.c_str(), FILE_READ);
  if (!f) { if(sdMutex) xSemaphoreGive(sdMutex); cl.stop(); return; }
  uint8_t buf[8192];
  while (f.available()) {
    int n = f.read(buf, sizeof(buf));
    if (sdMutex) xSemaphoreGive(sdMutex);
    cl.write(buf, n);               // TLS write outside mutex
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  }
  f.close();
  if (sdMutex) xSemaphoreGive(sdMutex);

  // Step 5: send closing boundary and drain response
  cl.print(tail);
  unsigned long t=millis(); while(!cl.available()&&millis()-t<15000) delay(10);
  while(cl.available()) cl.read();
  cl.stop();
  Serial.println("[TG] Photo sent OK");
}

void sendVideoToTelegram(const String& filePath, const String& caption) {
  if (!telegramEnabled) return;
  String fname = filePath.substring(filePath.lastIndexOf('/')+1);

  // Step 1: get file size under mutex
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File fSize = SD_MMC.open(filePath.c_str(), FILE_READ);
  size_t sz = fSize ? fSize.size() : 0;
  if (fSize) fSize.close();
  if (sdMutex) xSemaphoreGive(sdMutex);
  if (sz == 0) { Serial.println("[TG] Video: file not found or empty"); return; }

  // Step 2: TLS connect - no mutex held
  // Retry up to 3 times with 2s delay - camera reinit can briefly disturb WiFi stack
  WiFiClientSecure cl; cl.setCACert(TELEGRAM_CERTIFICATE_ROOT);
  bool tlsOk = false;
  for (int attempt = 1; attempt <= 3; attempt++) {
    if (cl.connect("api.telegram.org", 443, 20000)) { tlsOk = true; break; }
    Serial.printf("[TG] Video: TLS connect failed (attempt %d/3)\n", attempt);
    if (attempt < 3) { cl.stop(); delay(2000); }
  }
  if (!tlsOk) { Serial.println("[TG] Video: all TLS attempts failed"); return; }


  // Step 3: send HTTP headers
  const String bd = "ESP32VB456";
  String head =
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"chat_id\"\r\n\r\n"+cfgChatID+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"caption\"\r\n\r\n"+caption+"\r\n"
    "--"+bd+"\r\nContent-Disposition: form-data; name=\"document\"; filename=\""+fname+"\"\r\n"
    "Content-Type: video/x-msvideo\r\n\r\n";
  String tail = "\r\n--"+bd+"--\r\n";
  cl.printf("POST /bot%s/sendDocument HTTP/1.1\r\nHost: api.telegram.org\r\n"
            "Content-Type: multipart/form-data; boundary=%s\r\n"
            "Content-Length: %u\r\nConnection: close\r\n\r\n",
            cfgBotToken.c_str(), bd.c_str(), (unsigned)(head.length()+sz+tail.length()));
  cl.print(head);

  // Step 4: stream file bytes - release mutex between chunks
  // vTaskDelay every 20 chunks feeds the watchdog on Core 0 during long uploads.
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  File f = SD_MMC.open(filePath.c_str(), FILE_READ);
  if (!f) { if(sdMutex) xSemaphoreGive(sdMutex); cl.stop(); return; }
  uint8_t buf[2048];
  int chunkCount = 0;
  while (f.available()) {
    int n = f.read(buf, sizeof(buf));
    if (sdMutex) xSemaphoreGive(sdMutex);
    cl.write(buf, n);
    chunkCount++;
    if (chunkCount % 20 == 0) {
      vTaskDelay(pdMS_TO_TICKS(10));  // yield to IDLE0 - feeds task watchdog
    }
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  }
  f.close();
  if (sdMutex) xSemaphoreGive(sdMutex);

  // Step 5: closing boundary and drain
  cl.print(tail);
  unsigned long t=millis(); while(!cl.available()&&millis()-t<30000) delay(10);
  while(cl.available()) cl.read();
  cl.stop();
  Serial.println("[TG] Video sent OK");
}

// ============================================================
//  PHOTO CAPTURE - safe high-resolution still
//
//  Strategy: deinit camera ? reinit at UXGA ? capture ? reinit
//  back to stream config. This is the ONLY way to switch resolution
//  reliably on this hardware without FB-OVF errors.
//
//  Stream is stopped before deinit and restored after reinit.
// ============================================================
bool captureAndSavePhoto(bool sendTg, String triggerLabel, bool useFlash) {
  // -- 1. Stop stream and disarm motion ---------------------
  bool wasStreaming = streamActive;
  bool wasArmed     = motionArmed;
  streamActive = false;
  motionArmed  = false;
  delay(200);   // give httpd stream task time to finish its current frame

  // -- 2. Reinit camera at SVGA for reliable high-res still -----
  // SVGA (800x600, quality=8): 2x VGA area, fast AE settle, no blank frames.
  // UXGA was tried but caused blank frames on this hardware due to PSRAM limits.
  bool reinitOk = initCameraMode(PHOTO_FRAMESIZE, PHOTO_JPEG_QUALITY, 1);
  if (!reinitOk) {
    Serial.println("[CAM] Photo reinit failed, trying VGA fallback");
    reinitOk = initCameraMode(FRAMESIZE_VGA, PHOTO_JPEG_QUALITY, 1);
  }
  delay(350);   // OV2640 AE/AWB needs time to settle at new resolution

  // -- 3. Warm-up: discard 3 frames so AE/AWB fully settles ----
  for (int i = 0; i < 3; i++) {
    camera_fb_t* flush = esp_camera_fb_get();
    if (flush) esp_camera_fb_return(flush);
    delay(120);
  }

  // -- 4. Flash on -> discard pre-flash buffer -> capture -> flash off ----
  //
  // The OV2640 JPEG pipeline is double-buffered. When you turn the flash on
  // and immediately call esp_camera_fb_get(), you receive the frame that was
  // ALREADY being exposed before the flash fired. You need to:
  //   a) Turn flash ON
  //   b) Discard one frame (the one exposed without flash)
  //   c) Capture the next frame (now fully lit by the flash)
  //   d) Turn flash OFF
  //
  if (useFlash) {
    ledcWrite(FLASH_LED_PIN, 255);
    delay(50);   // let flash reach full brightness
    // Discard the frame that was buffered before flash fired
    camera_fb_t* preflash = esp_camera_fb_get();
    if (preflash) esp_camera_fb_return(preflash);
    delay(30);   // one extra frame period at ~15fps
  }
  camera_fb_t* fb = esp_camera_fb_get();
  if (useFlash) {
    ledcWrite(FLASH_LED_PIN, ledDuty);  // restore previous duty after flash
  }

  // -- 5. Save to SD -----------------------------------------
  bool ok = false;
  String path = "";
  if (fb) {
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
    SD_MMC.mkdir("/photos");
    path = "/photos/" + getTimestamp() + ".jpg";
    File out = SD_MMC.open(path.c_str(), FILE_WRITE);
    if (out) {
      out.write(fb->buf, fb->len);
      out.close();
      ok = true;
    }
    if (sdMutex) xSemaphoreGive(sdMutex);
    Serial.printf("[CAM] Saved %s (%u bytes, flash=%d)\n",
                  path.c_str(), (unsigned)fb->len, (int)useFlash);
    esp_camera_fb_return(fb);
    photoCount++;  // increment in-place; full rescan only at boot / deleteAllSD()
  } else {
    Serial.println("[CAM] Capture failed - fb==NULL");
  }

  // -- 6. Reinit camera back to stream mode -----------------
  {
    int fbCount = psramFound() ? 2 : 1;
    initCameraMode((framesize_t)streamFrameSize, STREAM_JPEG_QUALITY, fbCount);
  }
  delay(150);

  // Restore stream and motion state
  streamActive = wasStreaming;
  motionArmed  = wasArmed;
  if (wasArmed) { prevFrameReady = false; }   // reset motion baseline

  // -- 7. Send to Telegram with combined caption -------------
  if (ok && sendTg && telegramEnabled && bot) {
    String cap =
      "📸 Photo captured!\n"
      "📊 Photo #" + String(photoCount) + "\n"
      "💾 Saved to SD ✅\n"
      "⚡ Flash: " + (useFlash ? "ON" : "OFF") + "\n"
      "🔖 Trigger: " + triggerLabel;
    tgEnqueuePhoto(path, cap);
  }
  return ok;
}

// ============================================================
//  AVI WRITER
// ============================================================
static void writeU32LE(File& f, uint32_t v) {
  uint8_t b[4]={(uint8_t)v,(uint8_t)(v>>8),(uint8_t)(v>>16),(uint8_t)(v>>24)};
  f.write(b,4);
}
static void writeTag(File& f, const char* t){ f.write((const uint8_t*)t,4); }

// Extract actual pixel dimensions from a JPEG frame by scanning for SOF marker.
// This is the only reliable way to know the true frame size - the camera
// config framesize_t gives nominal sizes, but the actual JPEG may differ.
// OPT: Limit scan to first 512 bytes. In a well-formed OV2640 JPEG the SOF
// marker (FF C0/C2) appears within the first ~200 bytes after APP0/APP1.
// Scanning the full frame (10-30KB) risked hitting 0xFF bytes in pixel data.
static bool jpegGetDimensions(const uint8_t* buf, size_t len, int& w, int& h) {
  size_t scanLen = (len < 512) ? len : 512;
  for (size_t i = 0; i + 8 < scanLen; i++) {
    if (buf[i] == 0xFF && (buf[i+1] == 0xC0 || buf[i+1] == 0xC2)) {
      // SOF marker: FF C0/C2 <length(2)> <precision(1)> <height(2)> <width(2)>
      h = (buf[i+5] << 8) | buf[i+6];
      w = (buf[i+7] << 8) | buf[i+8];
      if (w > 0 && h > 0) return true;
    }
  }
  // Fallback: scan full frame if not found in header (non-standard JPEG)
  for (size_t i = 512; i + 8 < len; i++) {
    if (buf[i] == 0xFF && (buf[i+1] == 0xC0 || buf[i+1] == 0xC2)) {
      h = (buf[i+5] << 8) | buf[i+6];
      w = (buf[i+7] << 8) | buf[i+8];
      if (w > 0 && h > 0) return true;
    }
  }
  return false;
}

static void patchAVIHeader(File& f, int frames, int fps, int w, int h) {
  f.seek(0);
  if(fps<1)fps=1; if(fps>30)fps=30;
  uint32_t usf = 1000000u / (uint32_t)fps;
  const uint32_t avihSz=56, strhSz=56, strfSz=40;
  uint32_t strlBody = 4 + (4+4+strhSz) + (4+4+strfSz);
  uint32_t hdrlBody = 4 + (4+4+avihSz) + (4+4+strlBody);
  uint32_t maxBytes = (uint32_t)w * h * 3;

  // RIFF AVI header
  writeTag(f,"RIFF"); writeU32LE(f,(uint32_t)f.size()-8); writeTag(f,"AVI ");

  // hdrl LIST
  writeTag(f,"LIST"); writeU32LE(f,hdrlBody); writeTag(f,"hdrl");

  // avih - Main AVI header (56 bytes)
  writeTag(f,"avih"); writeU32LE(f,avihSz);
  writeU32LE(f,usf);          // dwMicroSecPerFrame
  writeU32LE(f,maxBytes);     // dwMaxBytesPerSec
  writeU32LE(f,0);            // dwPaddingGranularity
  writeU32LE(f,0x00);         // dwFlags: 0 (no idx1 chunk written, so AVIF_HASINDEX must NOT be set)
  writeU32LE(f,(uint32_t)frames); // dwTotalFrames
  writeU32LE(f,0);            // dwInitialFrames
  writeU32LE(f,1);            // dwStreams
  writeU32LE(f,maxBytes);     // dwSuggestedBufferSize
  writeU32LE(f,(uint32_t)w);  // dwWidth
  writeU32LE(f,(uint32_t)h);  // dwHeight
  for(int i=0;i<4;i++) writeU32LE(f,0); // reserved[4]

  // strl LIST (stream list)
  writeTag(f,"LIST"); writeU32LE(f,strlBody); writeTag(f,"strl");

  // strh - Stream header (56 bytes)
  writeTag(f,"strh"); writeU32LE(f,strhSz);
  writeTag(f,"vids");         // fccType: video stream
  writeTag(f,"MJPG");         // fccHandler: MJPEG codec
  writeU32LE(f,0);            // dwFlags
  writeU32LE(f,0);            // wPriority + wLanguage
  writeU32LE(f,0);            // dwInitialFrames
  writeU32LE(f,1);            // dwScale (time base numerator)
  writeU32LE(f,(uint32_t)fps);// dwRate  (frames per second)
  writeU32LE(f,0);            // dwStart
  writeU32LE(f,(uint32_t)frames); // dwLength
  writeU32LE(f,maxBytes);     // dwSuggestedBufferSize
  writeU32LE(f,0xFFFFFFFF);   // dwQuality (-1 = default)
  writeU32LE(f,0);            // dwSampleSize (0 = variable)
  // rcFrame: {left=0, top=0, right=w, bottom=h} as two 32-bit LE words
  writeU32LE(f,0);                          // left(16) | top(16)
  writeU32LE(f,((uint32_t)h<<16)|(uint32_t)w); // right(16) | bottom(16) -- actually bottom(16)|right(16)

  // strf - BITMAPINFOHEADER (40 bytes) for MJPEG video stream
  writeTag(f,"strf"); writeU32LE(f,strfSz);
  writeU32LE(f,strfSz);            // biSize
  writeU32LE(f,(uint32_t)w);       // biWidth
  // biHeight: NEGATIVE value signals top-down row order (required for MJPEG).
  // Without this, many players assume bottom-up and display incorrectly.
  // Store as two's complement uint32.
  writeU32LE(f,(uint32_t)(-(int32_t)h)); // biHeight (negative = top-down)
  writeU32LE(f,1u|(24u<<16));      // biPlanes=1, biBitCount=24
  writeTag(f,"MJPG");              // biCompression
  writeU32LE(f,maxBytes);          // biSizeImage
  writeU32LE(f,0);                 // biXPelsPerMeter
  writeU32LE(f,0);                 // biYPelsPerMeter
  writeU32LE(f,0);                 // biClrUsed
  writeU32LE(f,0);                 // biClrImportant
}

#define AVI_HDR_RESERVE 256
bool startAVIRecording(int durationSec) {
  if(aviRecording) return false;
  // Check free space: estimate ~150 MB max for a 120s recording; require at least 200 MB free
  uint64_t freeBytes = SD_MMC.totalBytes() - SD_MMC.usedBytes();
  if (freeBytes < 200ULL * 1024 * 1024) {
    Serial.printf("[AVI] Insufficient SD space: %.0f MB free\n", freeBytes / 1048576.0f);
    tgSend("SD card almost full - recording aborted. Free space: "
      + String((uint32_t)(freeBytes / 1048576)) + " MB");
    return false;
  }
  if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
  SD_MMC.mkdir("/videos");
  // Filename: YYYY-MM-DD_HH-MM-SS_<RES>_<DUR>s.avi
  String path = "/videos/" + getTimestamp() + "_" + getResLabel(streamFrameSize)
                + "_" + String(durationSec) + "s.avi";
  strncpy(aviFilePath, path.c_str(), sizeof(aviFilePath)-1);
  aviFile = SD_MMC.open(aviFilePath, FILE_WRITE);
  if(!aviFile){ if(sdMutex) xSemaphoreGive(sdMutex); Serial.println("[AVI] Open failed"); return false; }
  uint8_t zeros[AVI_HDR_RESERVE]={};
  aviFile.write(zeros, AVI_HDR_RESERVE);
  aviMoviOffset = (uint32_t)aviFile.position();
  writeTag(aviFile,"LIST"); writeU32LE(aviFile,0); writeTag(aviFile,"movi");
  aviFrameCount = 0; aviStartMs = millis(); aviRecording = true;
  aviWidth = 640; aviHeight = 480;  // defaults - updated from first real frame
  Serial.printf("[AVI] Start %s\n", aviFilePath);
  return true;
}

bool addAVIFrame(camera_fb_t* fb){
  if(!aviRecording||!fb||aviFrameCount>=AVI_MAX_FRAMES) return false;
  // Extract actual frame dimensions from first frame
  if(aviFrameCount == 0) {
    int fw=0, fh=0;
    if(jpegGetDimensions(fb->buf, fb->len, fw, fh) && fw>0 && fh>0) {
      aviWidth = fw; aviHeight = fh;
      Serial.printf("[AVI] Frame dims from JPEG: %dx%d\n", fw, fh);
    }
  }
  aviFrameCount++;
  writeTag(aviFile,"00dc"); writeU32LE(aviFile,fb->len);
  aviFile.write(fb->buf,fb->len);
  if(fb->len&1) aviFile.write((uint8_t)0);
  return true;
}

String finishAVIRecording(){
  if(!aviRecording) return "";
  aviRecording=false;
  unsigned long dur=millis()-aviStartMs;
  int fps=(dur>0)?(int)((aviFrameCount*1000UL)/dur):5;
  if(fps<1)fps=1; if(fps>30)fps=30;
  uint32_t end=(uint32_t)aviFile.size();
  uint32_t moviBody=end-aviMoviOffset-8;
  aviFile.seek(aviMoviOffset+4); writeU32LE(aviFile,moviBody+4);
  // Use actual detected dimensions - correct aspect ratio in any player
  patchAVIHeader(aviFile, aviFrameCount, fps, aviWidth, aviHeight);
  aviFile.close();
  if (sdMutex) xSemaphoreGive(sdMutex);
  videoCount++;  // increment in-place; full rescan only at boot / deleteAllSD()
  Serial.printf("[AVI] Done %d frames %dfps %dx%d\n",
    aviFrameCount, fps, aviWidth, aviHeight);
  return String(aviFilePath);
}

// ============================================================
//  MOTION DETECTION  - v2.2 complete rewrite
//
//  Algorithm: Mean Absolute Difference (MAD) on grayscale frames
//
//  Why MAD works better than pixel-count:
//    ? JPEG noise causes tiny random differences on EVERY pixel
//    ? Counting "pixels > threshold" catches ALL of them ? floods
//    ? MAD averages all differences ? JPEG noise averages to ~0-3
//    ? Real motion creates large per-pixel differences ? MAD spikes
//
//  Extra guards:
//    1. Warm-up: first MD_WARMUP_FRAMES frames after arming are
//       discarded so the sensor and AE settle (eliminates boot floods)
//    2. Consecutive: motion fires only after MD_CONSEC_REQUIRED
//       successive frames both exceed the threshold (eliminates
//       single-frame compression artefact triggers)
// ============================================================

// Decode JPEG to grayscale at 1/8 scale -> 80x60
// Uses jpg2rgb565 then converts RGB565->gray via a precomputed LUT.
//
// OPT: Two 256-entry lookup tables replace the per-pixel multiply chain.
//   hiLUT[hi] = R contribution + upper-G contribution to BT.601 luma
//   loLUT[lo] = lower-G contribution + B contribution to BT.601 luma
//   luma = clamp(hiLUT[hi] + loLUT[lo], 255)
// Cost per pixel: 2 table lookups + 1 add  (was: 6 shifts, 4 ORs, 3 muls)
// ~40% faster on Xtensa LX6 at 240 MHz.
static bool     grayLUTReady = false;
static uint8_t  hiLUT[256];   // R + upper-G luma contribution indexed by hi byte
static uint8_t  loLUT[256];   // lower-G + B luma contribution indexed by lo byte

static void buildGrayLUT() {
  if (grayLUTReady) return;
  // hi byte layout: RRRRRGGG  (R5 in bits[7:3], G_hi3 in bits[2:0])
  for (int hi = 0; hi < 256; hi++) {
    uint8_t r5  = (hi >> 3) & 0x1F;
    uint8_t gh3 = hi & 0x07;             // top 3 bits of G6
    uint8_t r8  = (r5 << 3) | (r5 >> 2);
    uint8_t g6h = gh3 << 3;              // bottom 3 G bits contributed by loLUT
    uint8_t g8h = (g6h << 2) | (g6h >> 4);
    uint16_t v  = (77u * r8 + 150u * g8h) >> 8;
    hiLUT[hi]   = (uint8_t)(v > 255 ? 255 : v);
  }
  // lo byte layout: GGGBBBBB  (G_lo3 in bits[7:5], B5 in bits[4:0])
  for (int lo = 0; lo < 256; lo++) {
    uint8_t gl3 = (lo >> 5) & 0x07;     // bottom 3 bits of G6
    uint8_t b5  = lo & 0x1F;
    uint8_t b8  = (b5 << 3) | (b5 >> 2);
    uint8_t g6l = gl3;
    uint8_t g8l = (g6l << 2) | (g6l >> 4);
    uint16_t v  = (150u * g8l + 29u * b8) >> 8;
    loLUT[lo]   = (uint8_t)(v > 255 ? 255 : v);
  }
  grayLUTReady = true;
}

static bool decodeToGray(camera_fb_t* fb, uint8_t* grayOut) {
  static uint8_t* rgb565Tmp = nullptr;
  const size_t tmpSz = MD_PIXELS * 2;

  if (!rgb565Tmp) {
    rgb565Tmp = psramFound()
      ? (uint8_t*)ps_malloc(tmpSz)
      : (uint8_t*)malloc(tmpSz);
    if (!rgb565Tmp) {
      Serial.println("[MD] decodeToGray: buffer alloc failed - motion disabled");
      return false;
    }
  }

  buildGrayLUT();  // no-op after first call

  if (!jpg2rgb565(fb->buf, fb->len, rgb565Tmp, JPG_SCALE_8X)) return false;

  // OPT: LUT lookup - 2 reads + 1 add per pixel replaces full multiply chain
  const uint8_t* src = rgb565Tmp;
  for (int i = 0; i < MD_PIXELS; i++) {
    uint16_t luma = (uint16_t)hiLUT[src[0]] + (uint16_t)loLUT[src[1]];
    grayOut[i] = (luma > 255) ? 255 : (uint8_t)luma;
    src += 2;
  }
  return true;
}

bool checkMotion(camera_fb_t* fb) {
  // Guard: armed, buffers ready, not recording
  if (!motionArmed || !prevGray || !currGray) return false;

  // Decode current frame to grayscale
  if (!decodeToGray(fb, currGray)) return false;

  // Warm-up phase: accumulate baseline frames, don't trigger.
  // OPT: Only memcpy on the LAST warm-up frame - previous copies were
  // immediately overwritten by the next frame's decode, so they were wasted.
  if (!mdWarmedUp) {
    mdWarmupCount++;
    if (mdWarmupCount >= MD_WARMUP_FRAMES) {
      // Final warm-up frame: latch it as the baseline and go active
      memcpy(prevGray, currGray, MD_PIXELS);
      prevFrameReady = true;
      mdWarmedUp = true;
      Serial.println("[MD] Warm-up complete - detection active");
    } else {
      Serial.printf("[MD] Warm-up %d/%d\n", mdWarmupCount, MD_WARMUP_FRAMES);
    }
    return false;
  }

  if (!prevFrameReady) {
    memcpy(prevGray, currGray, MD_PIXELS);
    prevFrameReady = true;
    return false;
  }

  // Compute Mean Absolute Difference across all pixels
  uint32_t sumDiff = 0;
  for (int i = 0; i < MD_PIXELS; i++) {
    sumDiff += (uint32_t)abs((int)currGray[i] - (int)prevGray[i]);
  }
  float mad = (float)sumDiff / MD_PIXELS;

  // Update previous frame
  memcpy(prevGray, currGray, MD_PIXELS);

  // Throttle serial output: print idle MAD at most once every 5 seconds
  static unsigned long lastMadPrintMs = 0;
  if (millis() - lastMadPrintMs >= 5000) {
    Serial.printf("[MD] MAD=%.2f threshold=%.2f\n", mad, mdThreshold);
    lastMadPrintMs = millis();
  }

  // Check against threshold
  if (mad > mdThreshold) {
    mdConsecutive++;
    Serial.printf("[MD] Hit %d/%d (MAD=%.2f)\n",
      mdConsecutive, MD_CONSEC_REQUIRED, mad);
    if (mdConsecutive >= MD_CONSEC_REQUIRED) {
      mdConsecutive = 0;   // reset for next event
      return true;         // REAL MOTION CONFIRMED
    }
  } else {
    // Reset consecutive counter if frame is calm
    mdConsecutive = 0;
  }
  return false;
}

// ============================================================
//  MJPEG STREAM SERVER  (port 81)
// ============================================================
#define STREAM_BD "ESP32SBound"
static const char* STREAM_CT   = "multipart/x-mixed-replace;boundary=" STREAM_BD;
// X-Timestamp matches CameraWebServer format - some clients use it for sync
static const char* STREAM_PART = "Content-Type: image/jpeg\r\nContent-Length: %u\r\nX-Timestamp: %d.%06d\r\n\r\n";

static esp_err_t streamHandler(httpd_req_t* req) {
  if (!streamActive) { httpd_resp_send_404(req); return ESP_OK; }
  httpd_resp_set_type(req, STREAM_CT);
  httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");
  httpd_resp_set_hdr(req, "X-Framerate", "60");
  const char* bnd = "\r\n--" STREAM_BD "\r\n";
  char hdr[128];  // enlarged to fit X-Timestamp

  int64_t frameIntervalUs = (streamFps > 0) ? (1000000 / streamFps) : 100000;
  int64_t lastFrameUs = esp_timer_get_time();

  while (streamActive) {
    camera_fb_t* fb = esp_camera_fb_get();
    if (!fb) break;
    httpd_resp_send_chunk(req, bnd, strlen(bnd));
    size_t hl = snprintf(hdr, sizeof(hdr), STREAM_PART, fb->len,
                         (int)fb->timestamp.tv_sec, (int)fb->timestamp.tv_usec);
    httpd_resp_send_chunk(req, hdr, hl);
    esp_err_t r = httpd_resp_send_chunk(req, (const char*)fb->buf, fb->len);
    esp_camera_fb_return(fb);
    if (r != ESP_OK) break;
    int64_t now = esp_timer_get_time();
    int64_t elapsed = now - lastFrameUs;
    if (elapsed < frameIntervalUs) {
      vTaskDelay(pdMS_TO_TICKS((frameIntervalUs - elapsed) / 1000));
    }
    lastFrameUs = esp_timer_get_time();
  }
  return ESP_OK;
}

void startStreamServer() {
  httpd_config_t cfg = HTTPD_DEFAULT_CONFIG();
  cfg.server_port    = 81;
  cfg.ctrl_port      = 32769;
  cfg.max_uri_handlers = 2;
  cfg.stack_size     = 8192;   // CameraWebServer uses 8KB stack for stream task
  cfg.send_wait_timeout = 10;  // seconds - prevents slow clients from blocking
  httpd_uri_t u = {"/stream", HTTP_GET, streamHandler, nullptr};
  if (httpd_start(&streamHttpd, &cfg) == ESP_OK) {
    httpd_register_uri_handler(streamHttpd, &u);
    Serial.println("[STREAM] :81/stream ready");
  }
}

// ============================================================
//  WEB SERVER  (port 80)
// ============================================================
void apiStatus() {
  float temp = temperatureRead();
  const char* rl[] = {
    "96x96","QQVGA","QCIF","HQVGA","240x240","QVGA 320x240","CIF 400x296",
    "HVGA 480x320","VGA 640x480","SVGA 800x600","XGA 1024x768",
    "HD 1280x720","SXGA 1280x1024","UXGA 1600x1200"
  };
  String resLabel = (streamFrameSize>=0&&streamFrameSize<=13) ? rl[streamFrameSize] : "VGA 640x480";
  StaticJsonDocument<640> doc;
  doc["uptime"]       = getUptime();
  doc["wifi"]         = (WiFi.status()==WL_CONNECTED);
  doc["ip"]           = WiFi.localIP().toString();
  doc["rssi"]         = WiFi.RSSI();
  doc["temp"]         = String(temp,1);
  doc["resolution"]   = resLabel + " @" + String(streamFps) + "fps";
  doc["streamRes"]    = streamFrameSize;
  doc["streamFps"]    = streamFps;
  doc["photos"]       = photoCount;
  doc["videos"]       = videoCount;
  doc["armed"]        = motionArmed;
  doc["warmedUp"]     = mdWarmedUp;
  doc["sensitivity"]  = motionSensitivity;
  doc["cooldown"]     = motionCooldownS;
  doc["recording"]    = aviRecording;
  doc["telegram"]     = telegramEnabled;
  doc["timelapse"]    = timelapseActive;
  doc["tlInterval"]   = timelapseIntervalS;
  doc["emailEnabled"] = emailEnabled;
  doc["freeHeap"]     = (uint32_t)(ESP.getFreeHeap()/1024);
  doc["freePsram"]    = (uint32_t)(ESP.getFreePsram()/1024);
  String out; serializeJson(doc,out);
  webServer.send(200,"application/json",out);
}

// ============================================================
//  /api/sdstats -- SD FAT queries on user demand only
// ============================================================
void apiSdStats() {
  uint64_t tot=SD_MMC.totalBytes(), used=SD_MMC.usedBytes();
  String t="Unknown";
  switch(SD_MMC.cardType()){
    case CARD_MMC:  t="MMC";        break;
    case CARD_SD:   t="SDSC";       break;
    case CARD_SDHC: t="SDHC/SDXC"; break;
    default: break;
  }
  StaticJsonDocument<192> doc;
  doc["sdType"]  = t;
  doc["sdTotal"] = (uint32_t)(tot/1048576);
  doc["sdUsed"]  = (uint32_t)(used/1048576);
  doc["sdFree"]  = (uint32_t)((tot-used)/1048576);
  String out; serializeJson(doc,out);
  webServer.send(200,"application/json",out);
}


// NEW: dedicated motion arm/disarm endpoint
void apiMotion() {
  if (webServer.hasArg("armed")) {
    int v = webServer.arg("armed").toInt();
    if (v) armMotion(); else disarmMotion();
  }
  webServer.send(200,"application/json",
    String("{\"armed\":")+( motionArmed?"true":"false")+"}");
}

// GET /api/timelapse?active=1&interval=30
void apiTimelapse() {
  if (webServer.hasArg("active")) {
    timelapseActive = webServer.arg("active").toInt() != 0;
    if (timelapseActive) lastTimelapseMs = 0; // fire first capture immediately
    Serial.printf("[TL] Timelapse %s\n", timelapseActive ? "STARTED" : "STOPPED");
  }
  if (webServer.hasArg("interval")) {
    timelapseIntervalS = constrain(webServer.arg("interval").toInt(), 1, 3600);
    Serial.printf("[TL] Interval set to %ds\n", timelapseIntervalS);
  }
  preferences.begin("surveil", false);
  preferences.putBool("tlActive",   timelapseActive);
  preferences.putInt ("tlInterval", timelapseIntervalS);
  preferences.end();
  webServer.send(200,"application/json",
    String("{\"active\":") + (timelapseActive?"true":"false") +
    ",\"interval\":" + String(timelapseIntervalS) + "}");
}

// Photo handler: schedule work in loop() and return immediately.
// captureAndSavePhoto() takes ~2s - we must not block handleClient().
void apiPhoto() {
  if (pendingJob.type != JOB_NONE) {
    webServer.send(503,"application/json","{\"ok\":false,\"error\":\"Busy\"}"); return;
  }
  pendingJob.flash = webServer.hasArg("flash") && webServer.arg("flash") == "1";
  pendingJob.type  = JOB_PHOTO;
  webServer.send(200,"application/json","{\"ok\":true,\"queued\":true}");
}

void apiStreamStart() {
  // Accept optional res/fps overrides from the start request
  if (webServer.hasArg("res")) {
    int r = webServer.arg("res").toInt();
    if (r >= 0 && r <= 13) { streamFrameSize = r; }
  }
  if (webServer.hasArg("fps")) {
    int f = webServer.arg("fps").toInt();
    if (f >= 1 && f <= 30) { streamFps = f; }
  }
  // Stop stream while we reinit camera (safe - nothing streaming yet)
  streamActive = false;
  delay(100);
  applyStreamResolution();
  delay(150);
  streamActive = true;
  webServer.send(200,"application/json","{\"ok\":true}");
}
void apiStreamStop() {
  streamActive = false;
  delay(150);   // let stream handler exit its loop
  webServer.send(200,"application/json","{\"ok\":true}");
}

void apiStreamQuality() {
  bool wasStreaming = streamActive;
  // Stop stream before changing resolution
  if (wasStreaming) {
    streamActive = false;
    delay(200);   // let httpd task finish current frame
  }
  if (webServer.hasArg("res")) {
    int r = webServer.arg("res").toInt();
    if (r >= 0 && r <= 13) { streamFrameSize = r; }
  }
  if (webServer.hasArg("fps")) {
    int f = webServer.arg("fps").toInt();
    if (f >= 1 && f <= 30) { streamFps = f; }
  }
  // Reinit camera at new resolution
  applyStreamResolution();
  delay(100);
  if (wasStreaming) { streamActive = true; }
  webServer.send(200,"application/json","{\"ok\":true}");
}

void apiRestart() {
  webServer.send(200,"application/json","{\"ok\":true}");
  delay(300);
  ESP.restart();
}

// Record handler: schedule work in loop() and return immediately.
// Recording takes 5-120s - blocking handleClient() would freeze dashboard.
void apiRecord(){
  int secs=webServer.hasArg("secs")?webServer.arg("secs").toInt():10;
  secs=constrain(secs,5,120);
  if(aviRecording||pendingJob.type!=JOB_NONE){
    webServer.send(200,"application/json","{\"ok\":false,\"error\":\"Busy\"}"); return;
  }
  pendingJob.recSecs = secs;
  pendingJob.type    = JOB_RECORD;
  webServer.send(200,"application/json","{\"ok\":true,\"queued\":true,\"secs\":"+String(secs)+"}");
}

// OPT: Cached file list - rebuilt only when photoCount or videoCount changes.
// The SD directory scan + sort is O(n log n) flash I/O; for typical use the
// file list is stable between captures so we serve the cached result.
struct FileEntry { char name[64]; char path[96]; size_t size; };
static std::vector<FileEntry> eventsCache;

static void rebuildEventsCache() {
  eventsCache.clear();
  eventsCache.reserve(64);
  auto scanDir = [](const char* dir) {
    File root = SD_MMC.open(dir);
    if (!root || !root.isDirectory()) return;
    File f = root.openNextFile();
    while (f) {
      if (!f.isDirectory()) {
        FileEntry e;
        strlcpy(e.name, f.name(),    sizeof(e.name));
        snprintf(e.path, sizeof(e.path), "%s/%s", dir, f.name());
        e.size = f.size();
        eventsCache.push_back(e);
      }
      f = root.openNextFile();
    }
    root.close();
  };
  scanDir("/photos");
  scanDir("/videos");
  std::sort(eventsCache.begin(), eventsCache.end(),
    [](const FileEntry& a, const FileEntry& b){ return strcmp(a.name, b.name) > 0; });
  eventsCachePhotoSnap = photoCount;
  eventsCacheVideoSnap = videoCount;
  eventsCacheDirty     = false;
}

void apiEvents(){
  int offset = webServer.hasArg("offset") ? webServer.arg("offset").toInt() : 0;
  int limit  = webServer.hasArg("limit")  ? webServer.arg("limit").toInt()  : EVENTS_PAGE_SIZE;
  limit = constrain(limit, 1, 100);

  // OPT: Only rescan SD when the file list has changed (dirty flag or count mismatch).
  if (eventsCacheDirty ||
      photoCount != eventsCachePhotoSnap ||
      videoCount != eventsCacheVideoSnap) {
    rebuildEventsCache();
  }

  int total = (int)eventsCache.size();
  DynamicJsonDocument doc(8192);
  doc["total"] = total;
  JsonArray arr = doc.createNestedArray("files");

  int end = min(offset + limit, total);
  for (int i = offset; i < end; i++) {
    JsonObject o = arr.createNestedObject();
    o["name"] = eventsCache[i].name;
    o["path"] = eventsCache[i].path;
    o["size"] = String(eventsCache[i].size / 1024) + " KB";
  }
  String out; serializeJson(doc, out);
  webServer.send(200, "application/json", out);
}

void apiDeleteAll() {
  int before = photoCount + videoCount;  // capture before deleteAllSD() resets counters
  deleteAllSD();
  eventsCacheDirty = true;  // OPT: force events cache rebuild after mass delete
  webServer.send(200, "application/json",
    "{\"ok\":true,\"count\":" + String(before) + "}");
}

void apiDownload(){
  if(!webServer.hasArg("f")){webServer.send(400,"text/plain","Missing f");return;}
  String path=webServer.arg("f");
  if(!path.startsWith("/photos/")&&!path.startsWith("/videos/")){webServer.send(403,"text/plain","Forbidden");return;}
  File f=SD_MMC.open(path.c_str(),FILE_READ);
  if(!f){webServer.send(404,"text/plain","Not found");return;}
  bool jpg=path.endsWith(".jpg")||path.endsWith(".jpeg");
  webServer.sendHeader("Content-Disposition","attachment; filename=\""+path.substring(path.lastIndexOf('/')+1)+"\"");
  webServer.streamFile(f,jpg?"image/jpeg":"video/x-msvideo"); f.close();
}
void apiThumb(){
  if(!webServer.hasArg("f")){webServer.send(404,"text/plain","No f");return;}
  String path=webServer.arg("f");
  if(!path.startsWith("/photos/")){webServer.send(403,"text/plain","Forbidden");return;}
  File f=SD_MMC.open(path.c_str(),FILE_READ);
  if(!f){webServer.send(404,"text/plain","Not found");return;}
  webServer.streamFile(f,"image/jpeg"); f.close();
}
void apiDelete(){
  if(!webServer.hasArg("f")){webServer.send(400,"application/json","{\"ok\":false}");return;}
  String path=webServer.arg("f");
  if(!path.startsWith("/photos/")&&!path.startsWith("/videos/")){webServer.send(403,"application/json","{\"ok\":false}");return;}
  bool ok=SD_MMC.remove(path.c_str());
  if(ok){
    if(path.startsWith("/photos/")) photoCount = max(0, photoCount - 1);
    else                            videoCount = max(0, videoCount - 1);
  }
  webServer.send(200,"application/json",ok?"{\"ok\":true}":"{\"ok\":false,\"error\":\"Delete failed\"}");
}
void apiConfig(){
  if(webServer.method()==HTTP_POST){
    StaticJsonDocument<768> doc;
    if(deserializeJson(doc,webServer.arg("plain"))){
      webServer.send(400,"application/json","{\"ok\":false}"); return;
    }
    bool needReboot = false;
    // Update in-RAM values immediately (these are used by the running system)
    if(doc.containsKey("sensitivity")){
      motionSensitivity=(int)doc["sensitivity"];
      mdThreshold=sliderToThreshold(motionSensitivity);
    }
    if(doc.containsKey("cooldown")){
      motionCooldownS=(int)doc["cooldown"];
    }
    if(doc.containsKey("wifiSSID")) needReboot=true;
    if(doc.containsKey("wifiPass")) needReboot=true;
    if(doc.containsKey("botToken")) needReboot=true;
    if(doc.containsKey("chatID"))   needReboot=true;
    // OPT: Send HTTP response BEFORE NVS flash writes.
    // Client gets its 200 OK instantly; NVS erase/write (~5-15ms per key)
    // happens after the TCP stack has queued the response bytes.
    // OPT: Single preferences.begin()/end() for all keys (was one open/close per key).
    webServer.send(200,"application/json",
      needReboot ? "{\"ok\":true,\"reboot\":true}" : "{\"ok\":true,\"reboot\":false}");
    preferences.begin("surveil", false);
    if(doc.containsKey("sensitivity")) preferences.putInt("motionSens", motionSensitivity);
    if(doc.containsKey("cooldown"))    preferences.putInt("motionCool", motionCooldownS);
    if(doc.containsKey("wifiSSID"))    preferences.putString("wifiSSID", doc["wifiSSID"].as<String>());
    if(doc.containsKey("wifiPass"))    preferences.putString("wifiPass", doc["wifiPass"].as<String>());
    if(doc.containsKey("botToken"))    preferences.putString("botToken", doc["botToken"].as<String>());
    if(doc.containsKey("chatID"))      preferences.putString("chatID",   doc["chatID"].as<String>());
    preferences.end();
    if(needReboot){ delay(800); ESP.restart(); }
  } else {
    StaticJsonDocument<512> doc;
    doc["sensitivity"]  = motionSensitivity;
    doc["cooldown"]     = motionCooldownS;
    preferences.begin("surveil", true);
    doc["wifiSSID"]     = preferences.getString("wifiSSID","");
    doc["tgConfigured"] = (preferences.getString("botToken","").length() > 0);
    preferences.end();
    doc["apMode"]       = apMode;
    String out; serializeJson(doc,out);
    webServer.send(200,"application/json",out);
  }
}


// ============================================================
//  CAMERA CONTROL - exact CameraWebServer approach
//  GET /control?var=brightness&val=2
//  One request per variable, direct sensor register write.
//  No JSON, no mutex, no stream stop. Works exactly like the
//  official Espressif CameraWebServer example.
// ============================================================
void apiCamControl() {
  if (!webServer.hasArg("var") || !webServer.hasArg("val")) {
    webServer.send(400, "text/plain", "Missing var or val"); return;
  }
  String var = webServer.arg("var");
  int    val = webServer.arg("val").toInt();
  sensor_t* s = esp_camera_sensor_get();
  if (!s) { webServer.send(500, "text/plain", "No sensor"); return; }

  int res = 0;
  if      (var == "framesize")     { if (s->pixformat == PIXFORMAT_JPEG) res = s->set_framesize(s, (framesize_t)val); }
  else if (var == "quality")       res = s->set_quality(s, val);
  else if (var == "contrast")      res = s->set_contrast(s, val);
  else if (var == "brightness")    res = s->set_brightness(s, val);
  else if (var == "saturation")    res = s->set_saturation(s, val);
  else if (var == "gainceiling")   res = s->set_gainceiling(s, (gainceiling_t)val);
  else if (var == "colorbar")      res = s->set_colorbar(s, val);
  else if (var == "awb")           res = s->set_whitebal(s, val);
  else if (var == "agc")           res = s->set_gain_ctrl(s, val);
  else if (var == "aec")           res = s->set_exposure_ctrl(s, val);
  else if (var == "hmirror")       res = s->set_hmirror(s, val);
  else if (var == "vflip")         res = s->set_vflip(s, val);
  else if (var == "awb_gain")      res = s->set_awb_gain(s, val);
  else if (var == "agc_gain")      res = s->set_agc_gain(s, val);
  else if (var == "aec_value")     res = s->set_aec_value(s, val);
  else if (var == "aec2")          res = s->set_aec2(s, val);
  else if (var == "dcw")           res = s->set_dcw(s, val);
  else if (var == "bpc")           res = s->set_bpc(s, val);
  else if (var == "wpc")           res = s->set_wpc(s, val);
  else if (var == "raw_gma")       res = s->set_raw_gma(s, val);
  else if (var == "lenc")          res = s->set_lenc(s, val);
  else if (var == "special_effect")res = s->set_special_effect(s, val);
  else if (var == "wb_mode")       res = s->set_wb_mode(s, val);
  else if (var == "ae_level")      res = s->set_ae_level(s, val);
  else if (var == "sharpness")     res = s->set_sharpness(s, val);
  else if (var == "led_intensity") {
    // LED intensity via LEDC PWM - same as CameraWebServer enable_led().
    // ledcWrite(pin, 0) fully cuts PWM output; no digitalWrite needed.
    ledDuty = constrain(val, 0, 255);
    ledcWrite(FLASH_LED_PIN, ledDuty);
    Serial.printf("[CAM] control: led_intensity = %d\n", ledDuty);
    webServer.send(200, "text/plain", "OK"); return;
  }
  else { webServer.send(404, "text/plain", "Unknown var"); return; }

  Serial.printf("[CAM] control: %s = %d (res=%d)\n", var.c_str(), val, res);
  if (res < 0) { webServer.send(500, "text/plain", "Sensor error"); return; }
  webServer.send(200, "text/plain", "OK");
}

// GET /xclk?xclk=20 - set XCLK frequency in MHz, same as CameraWebServer
void apiXclk() {
  if (!webServer.hasArg("xclk")) { webServer.send(400, "text/plain", "Missing xclk"); return; }
  int xclk = webServer.arg("xclk").toInt();
  xclk = constrain(xclk, 2, 40);
  sensor_t* s = esp_camera_sensor_get();
  if (!s) { webServer.send(500, "text/plain", "No sensor"); return; }
  int res = s->set_xclk(s, LEDC_TIMER_0, xclk);
  Serial.printf("[CAM] XCLK set to %d MHz (res=%d)\n", xclk, res);
  if (res != 0) { webServer.send(500, "text/plain", "XCLK error"); return; }
  webServer.send(200, "text/plain", "OK");
}

// GET /camstatus - reads actual sensor register values, same as CameraWebServer /status
// Dashboard calls this on load to populate all sliders with real current values.
void apiCamStatus() {
  sensor_t* s = esp_camera_sensor_get();
  if (!s) { webServer.send(500, "application/json", "{}"); return; }
  StaticJsonDocument<768> doc;
  doc["framesize"]      = s->status.framesize;
  doc["quality"]        = s->status.quality;
  doc["brightness"]     = s->status.brightness;
  doc["contrast"]       = s->status.contrast;
  doc["saturation"]     = s->status.saturation;
  doc["sharpness"]      = s->status.sharpness;
  doc["special_effect"] = s->status.special_effect;
  doc["wb_mode"]        = s->status.wb_mode;
  doc["awb"]            = s->status.awb;
  doc["awb_gain"]       = s->status.awb_gain;
  doc["aec"]            = s->status.aec;
  doc["aec2"]           = s->status.aec2;
  doc["ae_level"]       = s->status.ae_level;
  doc["aec_value"]      = s->status.aec_value;
  doc["agc"]            = s->status.agc;
  doc["agc_gain"]       = s->status.agc_gain;
  doc["gainceiling"]    = s->status.gainceiling;
  doc["bpc"]            = s->status.bpc;
  doc["wpc"]            = s->status.wpc;
  doc["raw_gma"]        = s->status.raw_gma;
  doc["lenc"]           = s->status.lenc;
  doc["hmirror"]        = s->status.hmirror;
  doc["vflip"]          = s->status.vflip;
  doc["dcw"]            = s->status.dcw;
  doc["colorbar"]       = s->status.colorbar;
  doc["xclk"]           = s->xclk_freq_hz / 1000000;  // MHz, matches CameraWebServer /status
  doc["led_intensity"]  = ledDuty;  // actual current PWM duty
  String out; serializeJson(doc, out);
  webServer.send(200, "application/json", out);
}

void initWebServer(){
  // Serve gzip-compressed dashboard (73% smaller than plain HTML)
  webServer.on("/",[](){ 
    webServer.sendHeader("Cache-Control","no-cache");
    webServer.sendHeader("Content-Encoding","gzip");
    webServer.send_P(200,"text/html",(const char*)DASHBOARD_HTML_GZ, DASHBOARD_HTML_GZ_LEN);
  });
  webServer.on("/api/status",          HTTP_GET,    apiStatus);
  webServer.on("/api/sdstats",         HTTP_GET,    apiSdStats);
  webServer.on("/api/photo",           HTTP_GET,    apiPhoto);
  webServer.on("/api/stream/start",    HTTP_GET,    apiStreamStart);
  webServer.on("/api/stream/stop",     HTTP_GET,    apiStreamStop);
  webServer.on("/api/stream/quality",  HTTP_GET,    apiStreamQuality);
  webServer.on("/api/motion",          HTTP_GET,    apiMotion);
  webServer.on("/api/timelapse",        HTTP_GET,    apiTimelapse);
  webServer.on("/api/record",          HTTP_GET,    apiRecord);
  webServer.on("/api/events",          HTTP_GET,    apiEvents);
  webServer.on("/api/download",        HTTP_GET,    apiDownload);
  webServer.on("/api/thumb",           HTTP_GET,    apiThumb);
  webServer.on("/api/delete",          HTTP_DELETE, apiDelete);
  webServer.on("/api/deleteall",       HTTP_DELETE, apiDeleteAll);
  webServer.on("/api/config",          HTTP_GET,    apiConfig);
  webServer.on("/api/config",          HTTP_POST,   apiConfig);
  webServer.on("/control",              HTTP_GET,    apiCamControl);  // CameraWebServer-compatible
  webServer.on("/camstatus",            HTTP_GET,    apiCamStatus);
  webServer.on("/xclk",                 HTTP_GET,    apiXclk);
  webServer.on("/api/restart",         HTTP_GET,    apiRestart);
  webServer.begin();
  Serial.println("[WEB] :80 ready");
}

// ============================================================
//  TELEGRAM COMMAND PROCESSOR
// ============================================================
void runTelegramRecord(int secs){
  tgSend("🎥 Starting "+String(secs)+"s "+getResLabel(streamFrameSize)+" recording...");
  if(!startAVIRecording(secs)){tgSend("? Could not start recording");return;}
  unsigned long dl=millis()+(unsigned long)(secs*1000);
  const unsigned long frameIntervalMs = 100;  // 10 fps - keeps file size manageable for Telegram upload
  while(millis()<dl){
    unsigned long frameStart = millis();
    camera_fb_t* fb=esp_camera_fb_get();
    if(fb){addAVIFrame(fb);esp_camera_fb_return(fb);}
    webServer.handleClient();
    unsigned long elapsed = millis() - frameStart;
    if (elapsed < frameIntervalMs) delay(frameIntervalMs - elapsed);
  }
  String path=finishAVIRecording();
  File vf=SD_MMC.open(path.c_str(),FILE_READ); uint32_t fsz=vf?vf.size():0; if(vf)vf.close();
  tgEnqueueVideo(path,
    "🎬 AVI Video recorded!\n"
    "📊 Stats:\n"
    "🎞 Frames: "+String(aviFrameCount)+"\n"
    "🎥 Resolution: "+String(aviWidth)+"x"+String(aviHeight)+"\n"
    "📁 Size: "+String(fsz/1024)+" KB\n"
    "⏱ Duration: "+String(secs)+"s\n"
    "💾 Saved to SD");
}


// ============================================================
//  SETUP
// ============================================================
// ============================================================
//  PENDING JOB EXECUTOR  (called from loop every iteration)
// ============================================================
void executePendingJob() {
  if (pendingJob.type == JOB_NONE) return;

  if (pendingJob.type == JOB_PHOTO) {
    pendingJob.type = JOB_NONE;  // clear before work so re-entrant calls see idle
    bool flash = pendingJob.flash;
    bool ok = captureAndSavePhoto(true, "Dashboard Button", flash);
    // Result is already sent via Telegram; /api/status reflects updated photoCount
    Serial.printf("[JOB] Photo done, ok=%d\n", (int)ok);
  }
  else if (pendingJob.type == JOB_RECORD) {
    int secs = pendingJob.recSecs;
    pendingJob.type = JOB_NONE;  // clear so motion/photo can run after record
    tgEnqueue("🎥 Starting "+String(secs)+"s "+getResLabel(streamFrameSize)+" recording...");
    if (!startAVIRecording(secs)) {
      tgEnqueue("Could not open file for recording");
      return;
    }
    unsigned long dl = millis() + (unsigned long)(secs * 1000);
    const unsigned long frameIntervalMs = 100;  // 10 fps - keeps file size manageable for Telegram upload
    while (millis() < dl) {
      unsigned long frameStart = millis();
      camera_fb_t* fb = esp_camera_fb_get();
      if (fb) { addAVIFrame(fb); esp_camera_fb_return(fb); }
      webServer.handleClient();  // keep web responsive during recording
      // Compensate for SD write + handleClient time to maintain even frame pacing
      unsigned long elapsed = millis() - frameStart;
      if (elapsed < frameIntervalMs) delay(frameIntervalMs - elapsed);
    }
    String path = finishAVIRecording();
    uint32_t fsz = 0;
    if (sdMutex) xSemaphoreTake(sdMutex, portMAX_DELAY);
    File vf = SD_MMC.open(path.c_str(), FILE_READ);
    fsz = vf ? vf.size() : 0; if (vf) vf.close();
    if (sdMutex) xSemaphoreGive(sdMutex);
    tgEnqueueVideo(path,
      "🎬 AVI Video recorded!\n"
      "📊 Stats:\n"
      "🎞 Frames: "+String(aviFrameCount)+"\n"
      "🎥 Resolution: "+String(aviWidth)+"x"+String(aviHeight)+"\n"
      "📁 Size: "+String(fsz/1024)+" KB\n"
      "⏱ Duration: "+String(secs)+"s\n"
      "💾 Saved to SD");
    Serial.printf("[JOB] Record done, %d frames\n", aviFrameCount);
  }
}

void setup(){
  WRITE_PERI_REG(RTC_CNTL_BROWN_OUT_REG,0);
  Serial.begin(115200); delay(1000);
  bootMs = millis();
  Serial.println("\n+======================================+");
  Serial.println("| ESP32-CAM Surveillance System v1.0  |");
  Serial.println("| Motion detection: OFF at boot        |");
  Serial.println("+======================================+");

  // Flash LED: use LEDC PWM so intensity slider works correctly.
  // ledcAttach replaces pinMode - same approach as CameraWebServer setupLedFlash().
  ledcAttach(FLASH_LED_PIN, FLASH_LEDC_FREQ, FLASH_LEDC_RES);
  ledcWrite(FLASH_LED_PIN, 0);  // start off

  preferences.begin("surveil", false);
  motionSensitivity  = preferences.getInt ("motionSens",  MOTION_SENSITIVITY_DEFAULT);
  motionCooldownS    = preferences.getInt ("motionCool",  MOTION_COOLDOWN_DEFAULT_S);
  mdThreshold        = sliderToThreshold(motionSensitivity);
  timelapseActive    = preferences.getBool("tlActive",    false);
  timelapseIntervalS = preferences.getInt ("tlInterval",  30);
  // Load credentials from NVS
  cfgWifiSSID = preferences.getString("wifiSSID", "");
  cfgWifiPass = preferences.getString("wifiPass", "");
  cfgBotToken = preferences.getString("botToken", "");
  cfgChatID   = preferences.getString("chatID",   "");
  preferences.end();  // close NVS namespace; reopen only when writing

  // Allocate motion detection buffers (grayscale only - 80x60 = 4800 bytes each)
  if(psramFound()){
    prevGray=(uint8_t*)ps_malloc(MD_PIXELS);
    currGray=(uint8_t*)ps_malloc(MD_PIXELS);
    Serial.println("[MD] PSRAM buffers OK");
  } else {
    prevGray=(uint8_t*)malloc(MD_PIXELS);
    currGray=(uint8_t*)malloc(MD_PIXELS);
    Serial.println("[MD] DRAM buffers OK");
  }
  if(!prevGray||!currGray) Serial.println("⚠ Motion buffer alloc failed");

  // Create SD mutex and Telegram queue/semaphore before any SD or WiFi use
  sdMutex  = xSemaphoreCreateMutex();
  tgBusySem = xSemaphoreCreateBinary();
  if (tgBusySem) xSemaphoreGive(tgBusySem);  // start in "not busy" state
  tgQueue  = xQueueCreate(4, sizeof(TgJob));
  if(!sdMutex || !tgQueue || !tgBusySem) Serial.println("[RTOS] Queue/Mutex/Sem alloc FAILED");

  if(!initCamera()){ Serial.println("[FATAL] Camera failed"); while(true) delay(1000); }

  if(!initSD()){
    Serial.println("⚠ No SD - media disabled");
  } else {
    SD_MMC.mkdir("/photos"); SD_MMC.mkdir("/videos");
    photoCount=countPhotos(); videoCount=countVideos();
    Serial.printf("[SD] %d photos, %d videos\n",photoCount,videoCount);
  }

  // Try STA mode if credentials exist
  if (cfgWifiSSID.length() > 0) {
    WiFi.mode(WIFI_STA);
    WiFi.begin(cfgWifiSSID.c_str(), cfgWifiPass.c_str());
    Serial.printf("[WiFi] Connecting to %s", cfgWifiSSID.c_str());
    for (int i = 0; i < 30 && WiFi.status() != WL_CONNECTED; i++) {
      delay(500); Serial.print(".");
    }
    Serial.println();
  }

  if (WiFi.status() == WL_CONNECTED) {
    apMode = false;
    Serial.println("[WiFi] Connected  IP: " + WiFi.localIP().toString());
    configTime(0, 0, NTP_SERVER);           // fetch UTC from NTP
    setenv("TZ", POSIX_TZ, 1);             // apply local timezone + DST rules
    tzset();
    delay(1500);
    // Init Telegram if credentials saved
    if (cfgBotToken.length() > 0 && cfgChatID.length() > 0) {
      telegramEnabled = true;
      securedClient.setCACert(TELEGRAM_CERTIFICATE_ROOT);
      bot = new UniversalTelegramBot(cfgBotToken.c_str(), securedClient);
      delay(2000);
      tgSend(
        "\xF0\x9F\x9A\x80 *Hellboy's WatchTower v1.0 Online!*\n\n"
        "\xF0\x9F\x93\xA1 IP: " + WiFi.localIP().toString() + "\n"
        "\xF0\x9F\x8F\xA0 Dashboard: http://" + WiFi.localIP().toString() + "\n"
        "\xF0\x9F\x93\xB6 WiFi: " + String(WiFi.RSSI()) + " dBm\n"
        "\xF0\x9F\x93\xB8 Photos on SD: " + String(photoCount) + "\n"
        "\xF0\x9F\x8E\xAC Videos on SD: " + String(videoCount) + "\n"
        "\xF0\x9F\x94\x95 Motion Detection: OFF (send /arm to enable)\n"
        "\xF0\x9F\x8E\xA5 Stream: VGA @10fps\n\n"
        "Send /help for all commands."
      );
      Serial.println("[TG] Bot ready");
      xTaskCreatePinnedToCore(
        telegramTask, "tgTask",
        16384, nullptr, 1, nullptr, 0);
      Serial.println("[RTOS] Telegram task started on Core 0");
    } else {
      Serial.println("[TG] No credentials - Telegram disabled");
      // Still start task so queue drains cleanly if credentials added later
      xTaskCreatePinnedToCore(
        telegramTask, "tgTask",
        16384, nullptr, 1, nullptr, 0);
    }
  } else {
    // No WiFi - start AP mode
    apMode = true;
    WiFi.mode(WIFI_AP);
    WiFi.softAP(AP_SSID, AP_PASS);
    delay(500);
    Serial.println("[WiFi] AP mode started");
    Serial.println("[WiFi] SSID: " AP_SSID "  Pass: " AP_PASS);
    Serial.println("[WiFi] Dashboard: http://" AP_IP_STR);
    // Start Telegram task anyway (queue must always be drained)
    xTaskCreatePinnedToCore(
      telegramTask, "tgTask",
      16384, nullptr, 1, nullptr, 0);
  }

  initWebServer();
  startStreamServer();

  Serial.println("[SYS] All systems GO");
  if (apMode) {
    Serial.println("[SYS] Mode: ACCESS POINT  SSID: " AP_SSID);
    Serial.println("[SYS] Dashboard -> http://" AP_IP_STR);
  } else {
    Serial.printf("[SYS] Mode: STA  IP: %s\n", WiFi.localIP().toString().c_str());
    Serial.printf("[SYS] Dashboard -> http://%s\n", WiFi.localIP().toString().c_str());
  }
  Serial.printf("[MD]  Threshold=%.2f  Cooldown=%ds  Warmup=%d frames\n",
    mdThreshold, motionCooldownS, MD_WARMUP_FRAMES);
}

// ============================================================
//  MAIN LOOP
// ============================================================
void loop(){
  webServer.handleClient();
  executePendingJob();  // run any queued photo/record job

  // WiFi reconnection watchdog (STA mode only)
  // If the router reboots or signal drops, attempt reconnect every 30 seconds.
  if (!apMode && WiFi.status() != WL_CONNECTED) {
    static unsigned long lastReconnectMs = 0;
    unsigned long now = millis();
    if (now - lastReconnectMs >= 30000) {
      lastReconnectMs = now;
      Serial.println("[WiFi] Connection lost - attempting reconnect...");
      WiFi.disconnect();
      WiFi.begin(cfgWifiSSID.c_str(), cfgWifiPass.c_str());
      // Wait up to 10 s for reconnect without blocking motion/web entirely
      for (int i = 0; i < 20 && WiFi.status() != WL_CONNECTED; i++) {
        delay(500);
        webServer.handleClient();
      }
      if (WiFi.status() == WL_CONNECTED) {
        Serial.println("[WiFi] Reconnected  IP: " + WiFi.localIP().toString());
        // Re-sync NTP after reconnect
        configTime(0, 0, NTP_SERVER);
        setenv("TZ", POSIX_TZ, 1);
        tzset();
        tgSend("WiFi reconnected. IP: " + WiFi.localIP().toString());
      } else {
        Serial.println("[WiFi] Reconnect failed - will retry in 30s");
      }
    }
  }

  // Motion detection block
  // Skipped entirely when: disarmed, recording, or within cooldown window
  if(motionArmed && !aviRecording){
    unsigned long now=millis();
    unsigned long coolMs=(unsigned long)(motionCooldownS*1000);

    if(now - lastMotionMs > coolMs){
      camera_fb_t* fb=esp_camera_fb_get();
      if(fb){
        bool motion=checkMotion(fb);
        esp_camera_fb_return(fb);

        if(motion){
          lastMotionMs=now;
          Serial.println("🏃 *** CONFIRMED ***");

          // Brief flash to illuminate scene
          ledcWrite(FLASH_LED_PIN, 255); delay(80); ledcWrite(FLASH_LED_PIN, ledDuty);

          // captureAndSavePhoto sends the photo WITH the caption - no second message needed
          captureAndSavePhoto(true,"Motion Detection",false);
        }
      }
    }
  }

  // Timelapse block
  // Skipped when: inactive, recording, or a job is already pending.
  if (timelapseActive && !aviRecording && pendingJob.type == JOB_NONE) {
    unsigned long now = millis();
    unsigned long tlMs = (unsigned long)(timelapseIntervalS * 1000UL);
    if (now - lastTimelapseMs >= tlMs) {
      lastTimelapseMs = now;
      Serial.printf("[TL] Capturing timelapse frame #%d\n", photoCount + 1);
      captureAndSavePhoto(false, "Timelapse", false);
    }
  }

  // OPT: Dynamic end-of-loop yield.
  // - Skip the delay entirely when a job is queued (execute it immediately next iteration).
  // - Use vTaskDelay() instead of delay() so FreeRTOS can schedule other tasks
  //   (telegramTask, IDLE0 watchdog) during the yield rather than busy-waiting.
  // - When motion is armed and inside the cooldown window, yield only 10ms so
  //   we can process webServer clients quickly without wasting time on a fixed 30ms stall.
  if (pendingJob.type != JOB_NONE) {
    // Work is waiting - don't delay at all, fall through to next loop() immediately
  } else if (motionArmed && !aviRecording) {
    vTaskDelay(pdMS_TO_TICKS(10));  // armed: stay responsive, ~100Hz check rate
  } else {
    vTaskDelay(pdMS_TO_TICKS(30));  // idle: ~33Hz, yields to WiFi + TG task
  }
}

/*
 * ===============================================================
 *  QUICK SETUP GUIDE  v1.0
 * ===============================================================
 *
 *  1. LIBRARIES  (Sketch > Include Library > Manage Libraries)
 *       "Universal Arduino Telegram Bot"  by Brian Lough
 *       "ArduinoJson"  v6.x  by Benoit Blanchon
 *
 *  2. BOARD MANAGER URL:
 *       https://raw.githubusercontent.com/espressif/arduino-esp32/
 *       gh-pages/package_esp32_index.json
 *       Board            : AI Thinker ESP32-CAM (HW-381 + OV2640)
 *       Partition Scheme : Huge APP (3MB No OTA / 1MB SPIFFS)
 *       CPU Frequency    : 240 MHz
 *
 *  3. FILL IN at top of file:
 *       WIFI_SSID / WIFI_PASS
 *       BOT_TOKEN  (@BotFather on Telegram ? /newbot)
 *       CHAT_ID    (@userinfobot on Telegram)
 *
 *  4. KEY ARCHITECTURE NOTES (v1.0):
 *       + WebServer retained - no library compatibility issues.
 *       + Telegram FreeRTOS task pinned Core 0. tgSend() non-blocking.
 *       + sdMutex guards all SD_MMC calls across both cores.
 *       + Pending-job state machine: apiPhoto/apiRecord return
 *         instantly; executePendingJob() runs the work in loop().
 *         webServer.handleClient() is called during recording so
 *         the dashboard stays responsive even during a 30s video.
 *       + Dashboard gzip: 31 KB -> 8.5 KB PROGMEM (73% smaller).
 *       + Resolution changes always use full camera deinit+reinit.
 *       + CAMERA_GRAB_LATEST with 2 PSRAM buffers prevents overflow.
 *       + AVI dimensions auto-detected from first-frame JPEG SOF.
 *
 *  5. TUNING MOTION SENSITIVITY:
 *       Open Serial Monitor (115200 baud) and watch "[MD] MAD=x.xx"
 *       Idle scene: MAD should be 0.5-3.0
 *       Motion in frame: MAD spikes to 10+
 *       Set MD_THRESHOLD_DEFAULT just above your idle noise value
 *
 *  6. MOTION IS OFF BY DEFAULT
 *       Enable via dashboard "Enable Motion" or /arm in Telegram
 *
 *  7. FILENAMES  (on SD card):
 *       Photos : /photos/YYYY-MM-DD_HH-MM-SS.jpg
 *       Videos : /videos/YYYY-MM-DD_HH-MM-SS_<RES>_<DUR>s.avi
 *       If NTP not synced: notime_<millis>.jpg / .avi
 * ===============================================================
 */
